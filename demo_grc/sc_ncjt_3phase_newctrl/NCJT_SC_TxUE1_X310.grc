options:
  parameters:
    author: ramin
    generate_options: qt_gui
    id: NCJT_SC_TxUE1_X310
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: ncjt.RG_FFT_SIZE[rgmode]
  states: {}
- name: init_code_rate
  id: variable
  parameters:
    value: '3'
  states: {}
- name: init_phase1_bits_per_sym
  id: variable
  parameters:
    value: '6'
  states: {}
- name: init_phase2_bits_per_sym
  id: variable
  parameters:
    value: '6'
  states: {}
- name: init_phase3_bits_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rgmode]
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rgmode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tx_frame_length
  id: variable
  parameters:
    value: num_data_syms * (fft_size + cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: usrp_address
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: ncjt_demapper_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    code_rate: init_code_rate
    mcs: 'True'
    noair: 'False'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    reset: 'False'
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: rgmode
  states: {}
- name: ncjt_mapper_muxer_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: init_code_rate
    debug: 'False'
    deterministic_input: deterministic
    nstrm: '1'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    rgmode: rgmode
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    logfreq: '50'
    ndatasymbols: num_data_syms
    nrx: '2'
    nss: '2'
    rgmode: rgmode
    showmaxllr: 'False'
  states: {}
- name: ncjt_noair_0_0
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: pkts_per_sec
    num_drop_init_packets: '0'
    rgmode: rgmode
    snr_db: '0'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '1'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rgmode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '1'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rgmode
    scaling: '0.5'
  states: {}
- name: ncjt_remapper_muxer_0_0_0
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: '1'
    rgmode: rgmode
  states: {}
- name: ncjt_rg_demapper_0_1
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: '1'
    phase: '1'
    rgmode: rgmode
    tag_snr: 'True'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    affinity: '2'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: '1'
    numue: '1'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_rg_mapper_0_1
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: '1'
    numue: '1'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    dataframelen: (fft_size+cp_len) * (num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '2000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: '0'
    p2preamblelen: '0'
    p2rx: 'False'
    p2start: (0.25/pkts_per_sec)
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '2'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/ncjt_preamble.bin"'
    frmdatalen: tx_frame_length
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.25/pkts_per_sec) + 5.0
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,1)
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_address
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_address
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_demapper_1, '0', ncjt_remapper_muxer_0_0_0, '0']
- [ncjt_knobs_0, s_code_rate, ncjt_mapper_muxer_0, s_code_rate]
- [ncjt_knobs_0, s_modtypes, ncjt_mapper_muxer_0, s_modtypes]
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mapper_muxer_0, '0', ncjt_rg_mapper_0_1, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [ncjt_noair_0_0, '0', ncjt_rg_demapper_0_1, '0']
- [ncjt_noair_0_0, '1', ncjt_rg_demapper_0_1, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_1, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_ofdm_mod_1, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_remapper_muxer_0_0_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_rg_demapper_0_1, '0', ncjt_demapper_1, '0']
- [ncjt_rg_demapper_0_1, '1', ncjt_demapper_1, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_rg_mapper_0_1, '0', ncjt_noair_0_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_1, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_frm_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_frm_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_1, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
