options:
  parameters:
    author: ramin
    generate_options: qt_gui
    id: NCJT_SC_RxUE2_X310
    output_language: python
    title: NCJT Demo (Rx UE2)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: ncjt.RG_FFT_SIZE[rgmode]
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rgmode]
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rgmode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: rx_ue_address_list
  id: variable
  parameters:
    value: '["addr=192.168.30.2" , "addr=192.168.60.2"]'
  states: {}
- name: rx_ue_address_list
  id: variable
  parameters:
    value: '["addr=192.168.60.2" , "addr=192.168.30.2"]'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tx_frame_length
  id: variable
  parameters:
    value: (num_data_syms+2) * (fft_size + cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: ue_idx
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: rx_ue_address_list[ue_idx]
  states: {}
- name: ncjt_demapper_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_err_stats_0
  id: ncjt_err_stats
  parameters:
    caption: ''
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: rgmode
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    debug: 'False'
    logfreq: '50'
    ndatasymbols: num_data_syms
    nrx: nss
    nss: nss
    rgmode: '0'
    showmaxllr: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '4'
    debug: 'False'
    logfreq: '50'
    mucpt: 'False'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: '0'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    cplen: cp_len
    rgmode: rgmode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    ntx: '2'
    rgmode: rgmode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_1
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    ntx: '2'
    rgmode: rgmode
    scaling: '0.5'
  states: {}
- name: ncjt_remapper_muxer_0
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: '1'
    rgmode: rgmode
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: '1'
    phase: '2'
    rgmode: '0'
    tag_snr: 'True'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    debug: 'False'
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2_t1.bin"'
    mucpt: 'True'
    nstrm: '1'
    numue: '2'
    rgmode: rgmode
    ueidx: ue_idx
  states: {}
- name: ncjt_rx_sync_0_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    affinity: '1'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '4000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: (fft_size+cp_len)*(2+num_data_syms)
    p2preamblelen: (fft_size+cp_len)*3
    p2rx: 'True'
    p2start: (0.25/pkts_per_sec)
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: '0'
  states: {}
- name: ncjt_tx_frm_ctrl_0_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '6'
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    frmdatalen: tx_frame_length
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.75/pkts_per_sec) + 5.0
  states: {}
- name: ncjt_ul_precoding_0
  id: ncjt_ul_precoding
  parameters:
    csifile: ''
    debug: 'False'
    eigenmode: 'True'
    loadcsi: 'False'
    ndatasyms: num_data_syms
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    rgmode: rgmode
    wideband: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"gNB S1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"gNB S2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"TxUE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0_1_0
  id: uhd_usrp_sink
  parameters:
    affinity: '6'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_demapper_0, '0', ncjt_err_stats_0, '0']
- [ncjt_demapper_0, '0', ncjt_remapper_muxer_0, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_1, '0']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_0, csi, ncjt_ul_precoding_0, csi]
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_1, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0_0, '1']
- [ncjt_ofdm_mod_1, '0', ncjt_tx_frm_ctrl_0_0, '0']
- [ncjt_remapper_muxer_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_demapper_0, '0']
- [ncjt_rg_demapper_0, '1', ncjt_demapper_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_ul_precoding_0, '0']
- [ncjt_rx_sync_0_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0_0, '1', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0_0, '2', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0_0, '3', ncjt_ofdm_demod_0_2, '0']
- [ncjt_rx_sync_0_0, rxrdy, ncjt_tx_frm_ctrl_0_0, txen]
- [ncjt_rx_sync_0_0, rxtime, ncjt_tx_frm_ctrl_0_0, rxtime]
- [ncjt_rx_sync_0_0, uhdcmd, uhd_usrp_source_0_0, command]
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_2, '0']
- [ncjt_tx_frm_ctrl_0_0, '0', uhd_usrp_sink_0_1_0, '0']
- [ncjt_tx_frm_ctrl_0_0, '1', uhd_usrp_sink_0_1_0, '1']
- [ncjt_ul_precoding_0, '0', ncjt_ofdm_mod_1, '0']
- [ncjt_ul_precoding_0, '1', ncjt_ofdm_mod_0, '0']
- [uhd_usrp_source_0_0, '0', ncjt_rx_sync_0_0, '0']
- [uhd_usrp_source_0_0, '1', ncjt_rx_sync_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
