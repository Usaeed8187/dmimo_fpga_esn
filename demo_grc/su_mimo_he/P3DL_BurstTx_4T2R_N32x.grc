options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3dl_bursttx_4t2r_n32x
    output_language: python
    title: Phase 3 DL BurstTX (4T2R)
  states: {}

blocks:
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '50'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txsig_s1.bin"'
    ntx: '1'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txsig_s3.bin"'
    ntx: '1'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txsig_s2.bin"'
    ntx: '1'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0_1
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txsig_s4.bin"'
    ntx: '1'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 245.76e6
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.60.2,addr1=192.168.40.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']
- [ncjt_burst_tx_0_0_0, '0', uhd_usrp_sink_0, '2']
- [ncjt_burst_tx_0_0_1, '0', uhd_usrp_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
