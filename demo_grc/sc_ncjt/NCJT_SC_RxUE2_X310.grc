options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_rxue2_x310
    output_language: python
    title: NCJT Demo (RxUE 2)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order*nss
  states: {}
- name: frame_data_len_p2
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_ctrl_syms_p3
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: ntx+nss
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '16'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.40.2"'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len_p2
    type: byte
  states: {state: disabled}
- name: ncjt_add_ctrldata_0_0
  id: ncjt_add_ctrldata
  parameters:
    add_llr: 'True'
    add_rxseq: 'True'
    add_txseq: 'False'
    affinity: '13'
    ctrl_datalen: 4*num_ctrl_syms_p3*sd_num
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    rgmode: '0'
  states: {}
- name: ncjt_check_ctrldata_0
  id: ncjt_check_ctrldata
  parameters:
    ctrl_datalen: 2*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'False'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '1'
    rgmode: rg_mode
    soffset: '0'
    waitrdy: 'False'
  states: {}
- name: ncjt_ltf_chanest_0_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '10'
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_mimo_detect_0_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '11'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: nss
    nss: nss
    rgmode: rg_mode
    showmaxllr: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '12'
    debug: 'True'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms+num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '10'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '12'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '10'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_3
  id: ncjt_ofdm_demod
  parameters:
    affinity: '12'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '15'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '15'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: nss
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '11'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len_p2
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    rgmode: rg_mode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_1
  id: ncjt_rg_demapper
  parameters:
    affinity: '13'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'False'
    minoutbuf: '32768'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '14'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len_p2
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2_t2.bin"'
    minoutbuf: '32768'
    mucpt: 'True'
    nctrlsyms: num_ctrl_syms_p3
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    rgmode: '0'
    ueidx: '1'
  states: {}
- name: ncjt_rx_sync_0_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '8'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '4000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: (fft_size+cp_len)*(2+num_data_syms+num_ctrl_syms_p2)
    p2preamblelen: (fft_size+cp_len)*3
    p2rx: 'True'
    p2start: (0.25/pkts_per_sec)
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_skip_data_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '13'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms+num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: ncjt_tx_frm_ctrl_0_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '9'
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    frmdatalen: (num_data_syms+num_ctrl_syms_p3+2) * (fft_size+cp_len)
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.75/pkts_per_sec) + 2.0
  states: {}
- name: ncjt_ul_precoding_0_0
  id: ncjt_ul_precoding
  parameters:
    affinity: '14'
    csifile: ''
    debug: 'False'
    eigenmode: 'False'
    loadcsi: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms_p3
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    rgmode: '0'
    wideband: 'True'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,2,2,2
    legend: 'False'
    name: '"gNB S2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"gNB S1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"TxUE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,6)
    label1: LMMSE
    label2: Rx2
    legend: 'False'
    nconnections: '2'
    size: '50'
    srate: '10'
    type: float
    update_time: '5'
    width1: '2'
    width2: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: reseterrs_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset Error Stats
    msgName: '"reseterrs"'
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_0_1_0_0
  id: uhd_usrp_sink
  parameters:
    affinity: '9'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    affinity: '8'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_add_ctrldata_0_0, '0']
- [ncjt_add_ctrldata_0_0, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_check_ctrldata_0, '0', ncjt_pkt_err_0_0_0, '0']
- [ncjt_ltf_chanest_0_0, '0', ncjt_mimo_detect_0_0, '0']
- [ncjt_ltf_chanest_0_0, '1', ncjt_mimo_detect_0_0, '1']
- [ncjt_ltf_chanest_0_0, csi, ncjt_ul_precoding_0_0, csi]
- [ncjt_mimo_detect_0_0, '0', ncjt_rg_demapper_1, '0']
- [ncjt_mimo_detect_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [ncjt_mimo_detect_0_0, '1', ncjt_rg_demapper_1, '1']
- [ncjt_mimo_detect_0_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_ltf_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_ltf_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_3, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_frm_ctrl_0_0, '1']
- [ncjt_ofdm_mod_0_1, '0', ncjt_tx_frm_ctrl_0_0, '0']
- [ncjt_pkt_err_0_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [ncjt_rg_demapper_0, '0', ncjt_add_ctrldata_0_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_check_ctrldata_0, '0']
- [ncjt_rg_demapper_1, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_rg_demapper_1, '1', ncjt_pkt_err_0_0, '1']
- [ncjt_rg_mapper_0_0, '0', ncjt_ul_precoding_0_0, '0']
- [ncjt_rx_sync_0_0, '0', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_rx_sync_0_0, '2', ncjt_ofdm_demod_0_3, '0']
- [ncjt_rx_sync_0_0, '3', ncjt_ofdm_demod_0_0_0_0, '0']
- [ncjt_rx_sync_0_0, rxrdy, ncjt_tx_frm_ctrl_0_0, txen]
- [ncjt_rx_sync_0_0, rxtime, ncjt_tx_frm_ctrl_0_0, rxtime]
- [ncjt_rx_sync_0_0, uhdcmd, uhd_usrp_source_0_0, command]
- [ncjt_skip_data_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', ncjt_skip_data_0, '0']
- [ncjt_stbc_decode_0, llr, ncjt_add_ctrldata_0_0, llr]
- [ncjt_tx_frm_ctrl_0_0, '0', uhd_usrp_sink_0_1_0_0, '0']
- [ncjt_tx_frm_ctrl_0_0, '1', uhd_usrp_sink_0_1_0_0, '1']
- [ncjt_ul_precoding_0_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_ul_precoding_0_0, '1', ncjt_ofdm_mod_0_0_0, '0']
- [reseterrs_1, pressed, ncjt_pkt_err_0_0, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_0, reset]
- [uhd_usrp_source_0_0, '0', ncjt_rx_sync_0_0, '0']
- [uhd_usrp_source_0_0, '1', ncjt_rx_sync_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
