options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_gnb_n32x
    output_language: python
    title: NCJT Demo (gNB)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_ctrl_syms_p3
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '75'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '65'
    value: '50'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.20.2"'
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_all.bin"'
    minoutbuf: '65536'
    ntx: '4'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_check_ctrldata_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '7'
    ctrl_datalen: 4*num_ctrl_syms_p3*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'True'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '2'
    rgmode: '0'
    soffset: '0'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '8'
    ctrl_datalen: 2*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '1'
    rgmode: '0'
    soffset: '0'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '4'
    ctrl_datalen: 2*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '1'
    rgmode: '0'
    soffset: '0'
    waitrdy: 'True'
  states: {}
- name: ncjt_gnb_sync_0
  id: ncjt_gnb_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    debug: 'False'
    hwdelayp2: '1715'
    hwdelayp3: '1715'
    maxcorrlen: '2000'
    nchans: '4'
    p2datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms_p2)
    p2preamblelen: (fft_size+cp_len)*3
    p2start: (0.25/pkts_per_sec)
    p3datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms_p3)
    p3preamblelen: (fft_size+cp_len)*3
    p3rx: 'True'
    p3start: (0.75/pkts_per_sec)
    pktspersec: pkts_per_sec
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_llr_combine_0
  id: ncjt_llr_combine
  parameters:
    affinity: '9'
    buffersize: '10'
    debug: 'False'
    llrsum: 'False'
    majority: 'False'
    minoutbuf: '32768'
    modtype1: qam_order
    modtype2: qam_order
    nstrm: '4'
    numsyms: num_data_syms
    sdnum: '52'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '7'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '65536'
    ndatasymbols: num_data_syms + num_ctrl_syms_p3
    nrx: '4'
    nss: '2'
    rgmode: '0'
    showmaxllr: 'True'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '7'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '65536'
    mucpt: 'True'
    ndatasyms: num_data_syms + num_ctrl_syms_p3
    npreamblesyms: '2'
    nrx: '4'
    ntx: '2'
    nue: '2'
    removecs: 'False'
    rgmode: '0'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '2'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: '0'
  states: {}
- name: ncjt_mu_chanest_0_1
  id: ncjt_mu_chanest
  parameters:
    affinity: '6'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: '0'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_3
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_4
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '9'
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data_2x.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '2'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0_1
  id: ncjt_pkt_err
  parameters:
    affinity: '9'
    avgwindow: '10'
    debug: 'True'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '4'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    rgmode: '0'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '8'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    rgmode: '0'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '7'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len * 2
    mergestrm: 'False'
    minoutbuf: '65536'
    nctrlsyms: num_ctrl_syms_p3
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    rgmode: '0'
    usecsi: 'False'
  states: {}
- name: ncjt_skip_data_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*8
  states: {}
- name: ncjt_skip_data_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*8
  states: {}
- name: ncjt_skip_data_0_1
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*8
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '4'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: '0'
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '8'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"RxUE 1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"RxUE 2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"TxUE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,2,6)
    label1: P2
    label2: PDC
    nconnections: '2'
    size: '40'
    srate: '4'
    type: float
    update_time: '2'
    width1: '2'
    width2: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: reseterrs_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset Error Stats
    msgName: '"reseterrs"'
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 122.88e6
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 122.88e6
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    nchan: '4'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_1, '0']
- [ncjt_burst_tx_0, '1', uhd_usrp_sink_1, '1']
- [ncjt_burst_tx_0, '2', uhd_usrp_sink_1, '2']
- [ncjt_burst_tx_0, '3', uhd_usrp_sink_1, '3']
- [ncjt_check_ctrldata_0, '0', ncjt_llr_combine_0, '2']
- [ncjt_check_ctrldata_0, '1', ncjt_llr_combine_0, '3']
- [ncjt_check_ctrldata_0_0, '0', ncjt_llr_combine_0, '1']
- [ncjt_check_ctrldata_0_0, '0', ncjt_pkt_err_0_0, '1']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_llr_combine_0, '0']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_gnb_sync_0, '0', ncjt_ofdm_demod_0_3, '0']
- [ncjt_gnb_sync_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_gnb_sync_0, '2', ncjt_ofdm_demod_0_4, '0']
- [ncjt_gnb_sync_0, '3', ncjt_ofdm_demod_0_0_1, '0']
- [ncjt_gnb_sync_0, '4', ncjt_ofdm_demod_0, '0']
- [ncjt_gnb_sync_0, '5', ncjt_ofdm_demod_0_0, '0']
- [ncjt_gnb_sync_0, '6', ncjt_ofdm_demod_0_2, '0']
- [ncjt_gnb_sync_0, '7', ncjt_ofdm_demod_0_1, '0']
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0, rxrdy]
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0_0, rxrdy]
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0_0_0, rxrdy]
- [ncjt_llr_combine_0, '0', blocks_null_sink_0_0_0, '0']
- [ncjt_llr_combine_0, '1', ncjt_pkt_err_0_0_1, '0']
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_0_0_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_skip_data_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_0_0_0, '1']
- [ncjt_mimo_detect_0, '1', ncjt_skip_data_0_0, '0']
- [ncjt_mimo_detect_0, maxllr, ncjt_check_ctrldata_0, llr]
- [ncjt_mu_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mu_chanest_0, '2', ncjt_mimo_detect_0, '2']
- [ncjt_mu_chanest_0, '3', ncjt_mimo_detect_0, '3']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_1, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_1, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_1, '0', ncjt_mu_chanest_0_1, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0, '3']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0, '2']
- [ncjt_ofdm_demod_0_3, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_4, '0', ncjt_mu_chanest_0_1, '0']
- [ncjt_pkt_err_0_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0_1, '0', qtgui_time_sink_x_0, '1']
- [ncjt_rg_demapper_0, '0', ncjt_check_ctrldata_0_0_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_check_ctrldata_0_0, '0']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_check_ctrldata_0, '0']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_check_ctrldata_0, '1']
- [ncjt_skip_data_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_skip_data_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [ncjt_skip_data_0_1, '0', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, llr, ncjt_check_ctrldata_0_0_0, llr]
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_stbc_decode_0_0, '2', ncjt_skip_data_0_1, '0']
- [ncjt_stbc_decode_0_0, llr, ncjt_check_ctrldata_0_0, llr]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_1, reset]
- [uhd_usrp_source_1, '0', ncjt_gnb_sync_0, '0']
- [uhd_usrp_source_1, '1', ncjt_gnb_sync_0, '1']
- [uhd_usrp_source_1, '2', ncjt_gnb_sync_0, '2']
- [uhd_usrp_source_1, '3', ncjt_gnb_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
