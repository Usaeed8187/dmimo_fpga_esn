options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_1tx_x310
    output_language: python
    title: NCJT SC 1Tx X310
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: ncjt.RG_FFT_SIZE[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sd_num*num_data_syms*qam_order
  states: {}
- name: freq_comp_1
  id: variable
  parameters:
    value: 2.850e3
  states: {state: disabled}
- name: freq_comp_2
  id: variable
  parameters:
    value: 4.5e3
  states: {state: disabled}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_data_sc_list
  id: variable
  parameters:
    value: '[52, 52, 234, 234, 132, 132, 132, 132]'
  states: {state: disabled}
- name: num_data_syms
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: pilot_sc_ind_list
  id: variable
  parameters:
    value: '[[7, 21, 34, 48],[7, 21, 34, 48],[6, 32, 74, 100, 141, 167, 209, 235],[6, 32, 74, 100, 141, 167, 209, 235],[9, 23, 49, 63, 76, 90, 116, 130],[9, 23, 49, 63, 76, 90, 116, 130],[9, 23, 49, 63, 76, 90, 116, 130],[9, 23, 49, 63, 76, 90, 116, 130]]'
  states: {state: disabled}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.55e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {state: disabled}
- name: rg_mode
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sc_num_list
  id: variable
  parameters:
    value: '[56, 56, 242, 242, 140, 140, 140, 140]'
  states: {state: disabled}
- name: sd_num
  id: variable
  parameters:
    value: ncjt.RG_NUM_DATA_SC[rg_mode]
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '19'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr0=192.168.30.2"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {state: disabled}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    code_rate: '0'
    mcs: 'True'
    noair: 'False'
    phase1_modtype: '2'
    phase2_modtype: '2'
    phase3_modtype: '2'
    reset: 'False'
  states: {}
- name: ncjt_mapper_muxer_0_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: '4'
    debug: 'False'
    deterministic_input: 'True'
    nstrm: '1'
    phase1_modtype: '2'
    phase2_modtype: '2'
    phase3_modtype: '2'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    affinity: '1'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: '1'
    numue: '1'
    rgmode: rg_mode
    ueidx: '0'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: rg_mode
    ueidx: '-1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/ncjt_preamble.bin"'
    frmdatalen: num_data_syms * (fft_size + cp_len)
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '5.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '2'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_knobs_0, s_code_rate, ncjt_mapper_muxer_0_0, s_code_rate]
- [ncjt_knobs_0, s_modtypes, ncjt_mapper_muxer_0_0, s_modtypes]
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
