options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_gnb_n32x
    output_language: python
    title: NCJT Demo (gNB)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms_p3
  id: variable
  parameters:
    value: '6'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '45'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"mgmt0=192.168.60.2,addr0=192.168.60.2,mgmt1=192.168.40.2,addr1=192.168.40.2"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
    vlen: '2'
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: int
    vlen: '2'
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    affinity: '0'
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s1.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '1.0'
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    affinity: '0'
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s3.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '1.0'
  states: {}
- name: ncjt_burst_tx_0_0_0
  id: ncjt_burst_tx
  parameters:
    affinity: '0'
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s2.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '1.0'
  states: {}
- name: ncjt_burst_tx_0_0_1
  id: ncjt_burst_tx
  parameters:
    affinity: '0'
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s4.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '1.0'
  states: {}
- name: ncjt_check_ctrldata_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '9'
    ctrl_datalen: 4*num_ctrl_syms_p3*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'True'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    nstrm: '2'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '5'
    ctrl_datalen: 2*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    nstrm: '1'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '3'
    ctrl_datalen: 2*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    nstrm: '1'
    waitrdy: 'True'
  states: {}
- name: ncjt_gnb_sync_0
  id: ncjt_gnb_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    debug: 'False'
    hwdelayp2: '1735'
    hwdelayp3: '1735'
    maxcorrlen: '2000'
    nchans: '4'
    p2datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms_p2)
    p2preamblelen: (fft_size+cp_len)*3
    p2start: (0.25/pkts_per_sec)
    p3datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms_p3)
    p3preamblelen: (fft_size+cp_len)*3
    p3start: (0.75/pkts_per_sec)
    pktspersec: pkts_per_sec
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_llr_combine_0
  id: ncjt_llr_combine
  parameters:
    affinity: '11'
    blocksize: '0'
    debug: 'False'
    llrsum: 'False'
    majority: 'True'
    minoutbuf: '32768'
    modtype1: qam_order
    modtype2: qam_order
    nstrm: '4'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '8'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms + num_ctrl_syms_p3
    nrx: '4'
    nss: '2'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '8'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'True'
    ndatasyms: num_data_syms + num_ctrl_syms_p3
    npreamblesyms: '2'
    nrx: '4'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '2'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
  states: {}
- name: ncjt_mu_chanest_0_1
  id: ncjt_mu_chanest
  parameters:
    affinity: '4'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '7'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    affinity: '7'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_3
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_4
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data_2x.bin"'
    logfreq: '50'
    nstrms: '2'
  states: {state: disabled}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data_2x.bin"'
    logfreq: '50'
    nstrms: '2'
  states: {}
- name: ncjt_pkt_err_0_0_1
  id: ncjt_pkt_err
  parameters:
    affinity: '11'
    berout: 'True'
    debug: 'True'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_pkt_err_0_0_1_0
  id: ncjt_pkt_err
  parameters:
    affinity: '11'
    berout: 'True'
    debug: 'False'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '3'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    fftsize: '64'
    framelen: frame_data_len
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '5'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    fftsize: '64'
    framelen: frame_data_len
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '9'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    fftsize: fft_size
    framelen: frame_data_len * 2
    mergestrm: 'False'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p3
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    usecsi: 'False'
  states: {}
- name: ncjt_skip_data_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: 52*8
  states: {}
- name: ncjt_skip_data_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: 52*8
  states: {}
- name: ncjt_skip_data_0_1
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: 52*8
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '3'
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npilotsyms: '0'
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms_p2
    npilotsyms: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"RxUE 1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"RxUE 2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"TxUE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    color3: blue
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,6)
    label1: P2
    label2: PDC
    label3: MAJ
    nconnections: '3'
    size: '40'
    srate: '4'
    type: float
    update_time: '1'
    width1: '2'
    width2: '2'
    width3: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: reseterrs_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset Error Stats
    msgName: '"reseterrs"'
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '0'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '0'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']
- [ncjt_burst_tx_0_0_0, '0', uhd_usrp_sink_0, '2']
- [ncjt_burst_tx_0_0_1, '0', uhd_usrp_sink_0, '3']
- [ncjt_check_ctrldata_0, '0', ncjt_llr_combine_0, '2']
- [ncjt_check_ctrldata_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_check_ctrldata_0, '1', ncjt_llr_combine_0, '3']
- [ncjt_check_ctrldata_0, '1', ncjt_pkt_err_0, '1']
- [ncjt_check_ctrldata_0_0, '0', ncjt_llr_combine_0, '1']
- [ncjt_check_ctrldata_0_0, '0', ncjt_pkt_err_0_0, '1']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_llr_combine_0, '0']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_gnb_sync_0, '0', ncjt_ofdm_demod_0_3, '0']
- [ncjt_gnb_sync_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_gnb_sync_0, '2', ncjt_ofdm_demod_0_4, '0']
- [ncjt_gnb_sync_0, '3', ncjt_ofdm_demod_0_0_1, '0']
- [ncjt_gnb_sync_0, '4', ncjt_ofdm_demod_0, '0']
- [ncjt_gnb_sync_0, '5', ncjt_ofdm_demod_0_0, '0']
- [ncjt_gnb_sync_0, '6', ncjt_ofdm_demod_0_2, '0']
- [ncjt_gnb_sync_0, '7', ncjt_ofdm_demod_0_1, '0']
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0, rxrdy]
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0_0, rxrdy]
- [ncjt_gnb_sync_0, rxrdy, ncjt_check_ctrldata_0_0_0, rxrdy]
- [ncjt_gnb_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_llr_combine_0, '0', blocks_null_sink_0_0_0, '0']
- [ncjt_llr_combine_0, '1', ncjt_pkt_err_0_0_1, '0']
- [ncjt_llr_combine_0, '2', ncjt_pkt_err_0_0_1_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_0_0_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_skip_data_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_0_0_0, '1']
- [ncjt_mimo_detect_0, '1', ncjt_skip_data_0_0, '0']
- [ncjt_mu_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mu_chanest_0, '2', ncjt_mimo_detect_0, '2']
- [ncjt_mu_chanest_0, '3', ncjt_mimo_detect_0, '3']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_1, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_1, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_1, '0', ncjt_mu_chanest_0_1, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0, '3']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0, '2']
- [ncjt_ofdm_demod_0_3, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_4, '0', ncjt_mu_chanest_0_1, '0']
- [ncjt_pkt_err_0, '0', blocks_null_sink_0_1, '0']
- [ncjt_pkt_err_0_0, '0', blocks_null_sink_0, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0_1, '0', blocks_null_sink_0_2, '0']
- [ncjt_pkt_err_0_0_1, '1', qtgui_time_sink_x_0, '1']
- [ncjt_pkt_err_0_0_1_0, '0', blocks_null_sink_0_2_0, '0']
- [ncjt_pkt_err_0_0_1_0, '1', qtgui_time_sink_x_0, '2']
- [ncjt_rg_demapper_0, '0', ncjt_check_ctrldata_0_0_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_check_ctrldata_0_0, '0']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_check_ctrldata_0, '0']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_check_ctrldata_0, '1']
- [ncjt_skip_data_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_skip_data_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [ncjt_skip_data_0_1, '0', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, llr, ncjt_check_ctrldata_0_0_0, llr]
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_stbc_decode_0_0, '2', ncjt_skip_data_0_1, '0']
- [ncjt_stbc_decode_0_0, llr, ncjt_check_ctrldata_0_0, llr]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_1, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_1_0, reset]
- [uhd_usrp_source_0, '0', ncjt_gnb_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_gnb_sync_0, '1']
- [uhd_usrp_source_0, '2', ncjt_gnb_sync_0, '2']
- [uhd_usrp_source_0, '3', ncjt_gnb_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
