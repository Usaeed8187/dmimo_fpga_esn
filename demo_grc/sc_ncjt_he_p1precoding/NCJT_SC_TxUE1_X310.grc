options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_demo_txue1_x310
    output_language: python
    title: NCJT Demo (TxUE1)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sd_num*num_data_syms*qam_order*ntx
  states: {}
- name: frame_data_len_p1r
  id: variable
  parameters:
    value: sd_num*num_data_syms_p1r*qam_order_p1r
  states: {}
- name: frame_data_len_p2
  id: variable
  parameters:
    value: sd_num*num_data_syms_p2*qam_order_p2
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms_p1r
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_data_syms_p1r
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_data_syms_p2
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_order_p1r
  id: variable
  parameters:
    value: '2'
  states: {}
- name: qam_order_p2
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: qam_type_p1r
  id: variable
  parameters:
    value: modulations[qam_order_p1r]
  states: {}
- name: qam_type_p2
  id: variable
  parameters:
    value: modulations[qam_order_p2]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '234'
  states: {}
- name: start_time_p1r
  id: variable
  parameters:
    value: (0.125/pkts_per_sec)
  states: {}
- name: start_time_p2
  id: variable
  parameters:
    value: (0.25/pkts_per_sec)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: usrp_address
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/sc_ncjt_he/1t1s/" + qam_type_p1r + "/strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: '"../../data/sc_ncjt_he/1t1s/" + qam_type + "/strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len_p1r
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len_p2
    type: byte
  states: {state: disabled}
- name: ncjt_add_ctrldata_0_0
  id: ncjt_add_ctrldata
  parameters:
    add_llr: 'False'
    add_rxseq: 'False'
    add_txseq: 'True'
    affinity: '6'
    ctrl_datalen: 4*num_ctrl_syms_p2*sd_num
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    rgmode: rg_mode
  states: {state: disabled}
- name: ncjt_add_ctrldata_0_0_0
  id: ncjt_add_ctrldata
  parameters:
    add_llr: 'True'
    add_rxseq: 'True'
    add_txseq: 'False'
    affinity: '5'
    ctrl_datalen: 4*num_ctrl_syms_p1r*sd_num
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    rgmode: rg_mode
  states: {}
- name: ncjt_check_ctrldata_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '3'
    ctrl_datalen: 4*num_ctrl_syms*sd_num
    debug: 'False'
    extract_llr: 'False'
    has_llr: 'False'
    has_rxseq: 'False'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '2'
    rgmode: rg_mode
    soffset: '0'
    waitrdy: 'False'
  states: {}
- name: ncjt_csi_quantizer_0
  id: ncjt_csi_quantizer
  parameters:
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    n_ofdm_syms_fb: num_data_syms_p1r
    nrx: '2'
    nss: '2'
    ntx: '4'
    rbg_size: '12'
  states: {}
- name: ncjt_dual_tx_ctrl_0
  id: ncjt_dual_tx_ctrl
  parameters:
    affinity: '7'
    autostart: 'False'
    beaconfile1: '"../../data/mu_mimo_he/2t2s/" + qam_type_p1r + "/preamble_noltfx.bin"'
    beaconfile2: '"../../data/sc_ncjt_he/1t1s/" + qam_type + "/ncjt_preamble.bin"'
    debug: 'False'
    frmdatalen1: (num_data_syms_p1r+num_ctrl_syms_p1r+2) * (fft_size+cp_len)
    frmdatalen2: (num_data_syms_p2+num_ctrl_syms_p2) * (fft_size+cp_len)
    minoutbuf: '32768'
    ntx: '2'
    padding: '500'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime1: start_time_p1r + 1.0
    starttime2: start_time_p2 + 2.0
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'True'
    debug: 'True'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '4'
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms + num_ctrl_syms
    nrx: ntx
    nss: ntx
    rgmode: rg_mode
    showmaxllr: 'False'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '6'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '2'
    shortterm: 'True'
  states: {}
- name: ncjt_rg_demapper_1
  id: ncjt_rg_demapper
  parameters:
    affinity: '13'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'False'
    nctrlsyms: num_ctrl_syms
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    affinity: '4'
    ctrlmodtype: '4'
    datamodtype: qam_order_p2
    debug: 'False'
    framelen: frame_data_len_p2
    ltfdata: ''
    minoutbuf: '32768'
    mucpt: 'False'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms_p2
    npilotsyms: '0'
    nstrms: '1'
    numue: '1'
    rgmode: rg_mode
    ueidx: '-1'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '5'
    ctrlmodtype: '4'
    datamodtype: qam_order_p1r
    debug: 'False'
    framelen: frame_data_len_p1r
    ltfdata: '"../../data/mu_mimo_he/2t2s/" + qam_type_p1r + "/ltf2x2_t1.bin"'
    minoutbuf: '32768'
    mucpt: 'True'
    nctrlsyms: num_ctrl_syms_p1r
    ndatasyms: num_data_syms_p1r
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '0'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    affinity: '1'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '2000'
    minoutbuf: '32768'
    nchans: '2'
    p1rx: 'True'
    p2framelen: '0'
    p2preamblelen: '0'
    p2rx: 'False'
    p2start: '0'
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_skip_data_0_1_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_skip_data_0_1_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '4'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p2+num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: rg_mode
    ueidx: '-1'
  states: {}
- name: ncjt_ul_precoding_0
  id: ncjt_ul_precoding
  parameters:
    affinity: '5'
    csifile: ''
    debug: 'False'
    eigenmode: 'True'
    loadcsi: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p1r + num_ctrl_syms_p1r
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    rgmode: rg_mode
    wideband: 'True'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"Tx gNB"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"Tx gNB"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,2,4)
    label1: LMMSE
    legend: 'False'
    size: '50'
    srate: '50'
    type: float
    update_time: '1'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '7'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_add_ctrldata_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', ncjt_add_ctrldata_0_0, '0']
- [ncjt_add_ctrldata_0_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_add_ctrldata_0_0_0, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_check_ctrldata_0_0, '0', ncjt_pkt_err_0_0_0, '0']
- [ncjt_check_ctrldata_0_0, '1', ncjt_pkt_err_0_0_0, '1']
- [ncjt_csi_quantizer_0, '0', blocks_null_sink_0, '0']
- [ncjt_csi_quantizer_0, '0', ncjt_add_ctrldata_0_0_0, '0']
- [ncjt_dual_tx_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_dual_tx_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_ltf_chanest_0, csi, ncjt_csi_quantizer_0, csi]
- [ncjt_ltf_chanest_0, csi, ncjt_ul_precoding_0, csi]
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_1, '0']
- [ncjt_mimo_detect_0, '0', ncjt_skip_data_0_1_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_1, '1']
- [ncjt_mimo_detect_0, '1', ncjt_skip_data_0_1_0_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_1, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_dual_tx_ctrl_0, '2']
- [ncjt_ofdm_mod_0_0, '0', ncjt_dual_tx_ctrl_0, '3']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_dual_tx_ctrl_0, '1']
- [ncjt_ofdm_mod_0_1, '0', ncjt_dual_tx_ctrl_0, '0']
- [ncjt_pkt_err_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_rg_demapper_1, '0', ncjt_check_ctrldata_0_0, '0']
- [ncjt_rg_demapper_1, '0', ncjt_rg_mapper_0, '0']
- [ncjt_rg_demapper_1, '1', ncjt_check_ctrldata_0_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_rg_mapper_0_0, '0', ncjt_ul_precoding_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_1, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_dual_tx_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_dual_tx_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_skip_data_0_1_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_skip_data_0_1_0_0, '0', qtgui_const_sink_x_0_1_0_0, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_ul_precoding_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_ul_precoding_0, '1', ncjt_ofdm_mod_0_0_0, '0']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
