options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_demo_rxs_gnb_pdc_n32x
    output_language: python
    title: NCJT Demo (Rx gNB)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sd_num*num_data_syms*qam_order*nss
  states: {}
- name: frame_data_len_p2
  id: variable
  parameters:
    value: sd_num*num_data_syms_p2*qam_order
  states: {}
- name: frame_data_len_p3
  id: variable
  parameters:
    value: sd_num*num_data_syms_p2*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_ctrl_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_ctrl_syms_p3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_data_syms_p2
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_data_syms_p3
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_data_syms_p3r
  id: variable
  parameters:
    value: '10'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '234'
  states: {}
- name: start_time_p2
  id: variable
  parameters:
    value: (0.25/pkts_per_sec)
  states: {}
- name: start_time_p3
  id: variable
  parameters:
    value: (0.5/pkts_per_sec)
  states: {}
- name: start_time_p3r
  id: variable
  parameters:
    value: (0.75/pkts_per_sec)
  states: {}
- name: tx_frame_size_p3r
  id: variable
  parameters:
    value: num_data_syms_p3r * (fft_size + cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"mgmt0=192.168.60.2,addr0=192.168.60.2,mgmt1=192.168.40.2,addr1=192.168.40.2"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txrgfrm_s1.bin"'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txrgfrm_s2.bin"'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txrgfrm_s3.bin"'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/txrgfrm_s4.bin"'
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    affinity: '15'
    len_tag_key: '"packet_len"'
    minoutbuf: '32768'
    packet_len: tx_frame_size_p3r
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    affinity: '15'
    len_tag_key: '"packet_len"'
    minoutbuf: '32768'
    packet_len: tx_frame_size_p3r
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    affinity: '15'
    len_tag_key: '"packet_len"'
    minoutbuf: '32768'
    packet_len: tx_frame_size_p3r
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_2
  id: blocks_stream_to_tagged_stream
  parameters:
    affinity: '15'
    len_tag_key: '"packet_len"'
    minoutbuf: '32768'
    packet_len: tx_frame_size_p3r
    type: complex
  states: {}
- name: ncjt_check_ctrldata_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '6'
    ctrl_datalen: 4*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '1'
    rgmode: rg_mode
    soffset: '0'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '4'
    ctrl_datalen: 4*num_ctrl_syms*sd_num
    debug: 'False'
    extract_llr: 'False'
    has_llr: 'False'
    has_rxseq: 'False'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '2'
    rgmode: rg_mode
    soffset: '0'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_0_0
  id: ncjt_check_ctrldata
  parameters:
    affinity: '7'
    ctrl_datalen: 4*num_ctrl_syms_p2*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'False'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '1'
    rgmode: rg_mode
    soffset: '1'
    waitrdy: 'True'
  states: {}
- name: ncjt_check_ctrldata_0_1
  id: ncjt_check_ctrldata
  parameters:
    affinity: '10'
    ctrl_datalen: 4*num_ctrl_syms_p3*sd_num
    debug: 'False'
    extract_llr: 'True'
    has_llr: 'True'
    has_rxseq: 'True'
    has_txseq: 'True'
    minoutbuf: '32768'
    msgout: 'False'
    nstrm: '2'
    rgmode: rg_mode
    soffset: '2'
    waitrdy: 'True'
  states: {}
- name: ncjt_llr_combine_0
  id: ncjt_llr_combine
  parameters:
    affinity: '11'
    buffersize: '20'
    debug: 'False'
    llrsum: 'False'
    majority: 'True'
    minoutbuf: '65536'
    modtype1: qam_order
    modtype2: qam_order
    nstrm: '4'
    numsyms: num_data_syms_p2
    sdnum: sd_num
  states: {}
- name: ncjt_mc_stbc_decode_0
  id: ncjt_mc_stbc_decode
  parameters:
    affinity: '3'
    debug: 'False'
    minoutbuf: '32768'
    modtype: qam_order
    ndatasyms: num_data_syms+num_ctrl_syms
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '10'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms_p3 + num_ctrl_syms_p3
    nrx: '4'
    nss: '2'
    rgmode: rg_mode
    showmaxllr: 'True'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '3'
    debug: 'True'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'True'
    ndatasyms: num_data_syms+num_ctrl_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: ntx
    nue: '2'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '10'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'True'
    ndatasyms: num_data_syms_p3 + num_ctrl_syms_p3
    npreamblesyms: '2'
    nrx: '4'
    ntx: '2'
    nue: '2'
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_mu_chanest_0_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '6'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms_p2+num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_mu_chanest_0_1
  id: ncjt_mu_chanest
  parameters:
    affinity: '7'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms_p2 + num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_1_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_4
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0_0_1
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '2'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0_1
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_0_1_0
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_pkt_err_0_1
  id: ncjt_pkt_err
  parameters:
    avgwindow: '10'
    debug: 'False'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    logfreq: '50'
    logpkterr: 'False'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '4'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'False'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '6'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len_p2
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms_p2
    npilotsyms: '0'
    nstrm: '1'
    rgmode: rg_mode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '10'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len_p3 * 2
    mergestrm: 'False'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p3
    ndatasyms: num_data_syms_p3
    npilotsyms: '0'
    nstrm: '2'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_demapper_0_0_1
  id: ncjt_rg_demapper
  parameters:
    affinity: '7'
    ctrlmodtype: '4'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len_p2
    mergestrm: 'True'
    minoutbuf: '32768'
    nctrlsyms: num_ctrl_syms_p2
    ndatasyms: num_data_syms_p2
    npilotsyms: '0'
    nstrm: '1'
    rgmode: rg_mode
    usecsi: 'True'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    affinity: '1'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms)
    debug: 'False'
    hwdelayp2: '820'
    hwdelayp3: '820'
    lltf2: 'True'
    maxcorrlen: '2000'
    nchans: '4'
    p1rx: 'True'
    p2framelen: (fft_size+cp_len)*(2+num_data_syms_p2+num_ctrl_syms_p2)
    p2preamblelen: (fft_size+cp_len)
    p2rx: 'True'
    p2start: start_time_p2
    p3framelen: (fft_size+cp_len)*(2+num_data_syms_p3+num_ctrl_syms_p3)
    p3preamblelen: (fft_size+cp_len)
    p3rx: 'True'
    p3start: start_time_p3
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_skip_data_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_skip_data_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_skip_data_0_1_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_skip_data_0_1_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '6'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p2+num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: ncjt_stbc_decode_0_0_1
  id: ncjt_stbc_decode
  parameters:
    affinity: '7'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p2 + num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '15'
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/su_mimo_he/4t2s_csd/" + qam_type + "/preamble.bin"'
    frmdatalen: tx_frame_size_p3r
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '4'
    padding: '500'
    pktspersec: pkts_per_sec
    starttime: start_time_p3r + 2.0
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"RxUE 1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,6,2,2)
    legend: 'False'
    name: '"RxUE 2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"Tx gNB"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"Tx UE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.75'
    alpha2: '0.75'
    alpha3: '0.75'
    alpha4: '0.75'
    alpha5: '0.75'
    autoscale: 'True'
    color2: dark green
    color3: red
    color4: magenta
    color5: black
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,2,8)
    label1: TxUE
    label2: RxUE
    label3: PDC
    label4: MAJ
    label5: TxgNB
    nconnections: '5'
    size: '40'
    srate: '4'
    type: float
    update_time: '1'
    width1: '2'
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: reseterrs_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: Reset Error Stats
    msgName: '"reseterrs"'
    type: int
    value: '1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '15'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 245.76e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 245.76e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_file_source_0_2, '0', blocks_stream_to_tagged_stream_0_2, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [blocks_stream_to_tagged_stream_0_1, '0', ncjt_tx_frm_ctrl_0, '2']
- [blocks_stream_to_tagged_stream_0_2, '0', ncjt_tx_frm_ctrl_0, '3']
- [ncjt_check_ctrldata_0, '0', ncjt_llr_combine_0, '0']
- [ncjt_check_ctrldata_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_check_ctrldata_0_0, '0', ncjt_pkt_err_0_0_0_1, '0']
- [ncjt_check_ctrldata_0_0, '1', ncjt_pkt_err_0_0_0_1, '1']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_llr_combine_0, '1']
- [ncjt_check_ctrldata_0_0_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_check_ctrldata_0_1, '0', ncjt_llr_combine_0, '2']
- [ncjt_check_ctrldata_0_1, '0', ncjt_pkt_err_0_1, '0']
- [ncjt_check_ctrldata_0_1, '1', ncjt_llr_combine_0, '3']
- [ncjt_llr_combine_0, '0', blocks_null_sink_0_0_0, '0']
- [ncjt_llr_combine_0, '1', ncjt_pkt_err_0_0_1, '0']
- [ncjt_llr_combine_0, '2', ncjt_pkt_err_0_0_1_0, '0']
- [ncjt_mc_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_mc_stbc_decode_0, '0', ncjt_skip_data_0_1_0, '0']
- [ncjt_mc_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_0_0_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_skip_data_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_0_0_0, '1']
- [ncjt_mimo_detect_0, '1', ncjt_skip_data_0_0, '0']
- [ncjt_mimo_detect_0, maxllr, ncjt_check_ctrldata_0_1, llr]
- [ncjt_mu_chanest_0, '0', ncjt_mc_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_mc_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mu_chanest_0_0, '2', ncjt_mimo_detect_0, '2']
- [ncjt_mu_chanest_0_0, '3', ncjt_mimo_detect_0, '3']
- [ncjt_mu_chanest_0_0_0, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_0_0, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_mu_chanest_0_1, '0', ncjt_stbc_decode_0_0_1, '0']
- [ncjt_mu_chanest_0_1, '1', ncjt_stbc_decode_0_0_1, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0_0, '1']
- [ncjt_ofdm_demod_0_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_0_0_0, '0', ncjt_mu_chanest_0_0, '2']
- [ncjt_ofdm_demod_0_0_0_0_1, '0', ncjt_mu_chanest_0_0, '3']
- [ncjt_ofdm_demod_0_0_1, '0', ncjt_mu_chanest_0_1, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0_0_0, '0']
- [ncjt_ofdm_demod_0_1_0, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_4, '0', ncjt_mu_chanest_0_1, '0']
- [ncjt_pkt_err_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0, '0', blocks_null_sink_0_0_0_0_0, '0']
- [ncjt_pkt_err_0_0_0_1, '0', blocks_null_sink_0_0_0_0, '0']
- [ncjt_pkt_err_0_0_0_1, '0', qtgui_time_sink_x_0, '4']
- [ncjt_pkt_err_0_0_1, '0', qtgui_time_sink_x_0, '2']
- [ncjt_pkt_err_0_0_1_0, '0', qtgui_time_sink_x_0, '3']
- [ncjt_pkt_err_0_1, '0', qtgui_time_sink_x_0, '1']
- [ncjt_rg_demapper_0, '0', ncjt_check_ctrldata_0_0, '0']
- [ncjt_rg_demapper_0, '1', ncjt_check_ctrldata_0_0, '1']
- [ncjt_rg_demapper_0_0, '0', ncjt_check_ctrldata_0, '0']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_check_ctrldata_0_1, '0']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_check_ctrldata_0_1, '1']
- [ncjt_rg_demapper_0_0_1, '0', ncjt_check_ctrldata_0_0_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0, '10', ncjt_ofdm_demod_0_0_0_0_0, '0']
- [ncjt_rx_sync_0, '11', ncjt_ofdm_demod_0_0_0_0_1, '0']
- [ncjt_rx_sync_0, '2', blocks_null_sink_0, '0']
- [ncjt_rx_sync_0, '3', blocks_null_sink_0_0, '0']
- [ncjt_rx_sync_0, '4', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0, '5', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_rx_sync_0, '6', ncjt_ofdm_demod_0_4, '0']
- [ncjt_rx_sync_0, '7', ncjt_ofdm_demod_0_0_1, '0']
- [ncjt_rx_sync_0, '8', ncjt_ofdm_demod_0_1_0, '0']
- [ncjt_rx_sync_0, '9', ncjt_ofdm_demod_0_0_0_0, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_check_ctrldata_0, rxrdy]
- [ncjt_rx_sync_0, rxrdy, ncjt_check_ctrldata_0_0, rxrdy]
- [ncjt_rx_sync_0, rxrdy, ncjt_check_ctrldata_0_0_0, rxrdy]
- [ncjt_rx_sync_0, rxrdy, ncjt_check_ctrldata_0_1, rxrdy]
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_frm_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_frm_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_skip_data_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_skip_data_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [ncjt_skip_data_0_1_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_skip_data_0_1_0_0, '0', qtgui_const_sink_x_0_1_0_0, '0']
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_stbc_decode_0_0, '2', ncjt_skip_data_0_1_0_0, '0']
- [ncjt_stbc_decode_0_0, llr, ncjt_check_ctrldata_0, llr]
- [ncjt_stbc_decode_0_0_1, '0', ncjt_rg_demapper_0_0_1, '0']
- [ncjt_stbc_decode_0_0_1, '1', ncjt_rg_demapper_0_0_1, '1']
- [ncjt_stbc_decode_0_0_1, llr, ncjt_check_ctrldata_0_0_0, llr]
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_frm_ctrl_0, '2', uhd_usrp_sink_0, '2']
- [ncjt_tx_frm_ctrl_0, '3', uhd_usrp_sink_0, '3']
- [reseterrs_1, pressed, ncjt_pkt_err_0, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_0_1, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_1, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_0_1_0, reset]
- [reseterrs_1, pressed, ncjt_pkt_err_0_1, reset]
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']
- [uhd_usrp_source_0, '2', ncjt_rx_sync_0, '2']
- [uhd_usrp_source_0, '3', ncjt_rx_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
