options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_demo_txs_gnb_n310
    output_language: python
    title: NCJT Demo (TxS gNB)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len_p1
  id: variable
  parameters:
    value: sd_num*num_data_syms_p1*qam_order_p1
  states: {}
- name: frame_data_len_p1r
  id: variable
  parameters:
    value: sd_num*num_data_syms_p1r*qam_order_p1r
  states: {}
- name: init_code_rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: init_phase1_bits_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: init_phase2_bits_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: init_phase3_bits_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_ctrl_syms_p1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_ctrl_syms_p1r
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_data_syms_p1
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: num_data_syms_p1r
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: num_ltf_syms_p1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order_p1
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_order_p1r
  id: variable
  parameters:
    value: '2'
  states: {}
- name: qam_type_p1
  id: variable
  parameters:
    value: modulations[qam_order_p1]
  states: {}
- name: qam_type_p1r
  id: variable
  parameters:
    value: modulations[qam_order_p1r]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sc_num
  id: variable
  parameters:
    value: '242'
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: ncjt.RG_NUM_DATA_SC[rg_mode]
  states: {}
- name: start_time_p1r
  id: variable
  parameters:
    value: (0.125/pkts_per_sec)
  states: {}
- name: tx_frame_len_p1
  id: variable
  parameters:
    value: (num_data_syms_p1+num_ctrl_syms_p1+2) * (fft_size + cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"mgmt0=192.168.60.2,addr0=192.168.60.2,mgmt1=192.168.40.2,addr1=192.168.40.2"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: ncjt_csi_fb_processing_0
  id: ncjt_csi_fb_processing
  parameters:
    cqi_bits: '8'
    crc_bits: '10'
    debug: 'True'
    nrb: '1'
    nss: '2'
    ntx_gnb: '4'
    num_ue: '2'
    pmi_bits: '5'
    polar_code_rate: '0.5'
    rx_modtype: '1'
    total_csi_bits: '128'
    wideband: 'True'
  states: {state: disabled}
- name: ncjt_demapper_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_demapper_1_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_err_stats_0
  id: ncjt_err_stats
  parameters:
    caption: Tx UE to Tx gNB Transmission S1
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {state: disabled}
- name: ncjt_err_stats_1
  id: ncjt_err_stats
  parameters:
    caption: Tx UE to Tx gNB Transmission S2
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {state: disabled}
- name: ncjt_gnb_sync_0
  id: ncjt_gnb_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    debug: 'False'
    hwdelayp2: '810'
    hwdelayp3: '810'
    maxcorrlen: '2000'
    nchans: '4'
    p2datalen: (fft_size+cp_len)*(num_ltf_syms_p1+num_data_syms_p1r+num_ctrl_syms_p1r)
    p2preamblelen: (fft_size+cp_len)
    p2start: start_time_p1r
    p3datalen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    code_rate: init_code_rate
    mcs: 'True'
    noair: 'False'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    reset: 'False'
  states: {}
- name: ncjt_mapper_muxer_0_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: init_code_rate
    debug: 'False'
    deterministic_input: deterministic
    nstrm: '1'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    rgmode: rg_mode
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '6'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'True'
    ndatasyms: num_data_syms_p1r + num_ctrl_syms_p1r
    npreamblesyms: '2'
    nrx: '4'
    ntx: '2'
    nue: '2'
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    affinity: '5'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_p1_precoding_0
  id: ncjt_p1_precoding
  parameters:
    debug: 'False'
    logfreq: '50'
    minoutbuf: '65536'
    nfft: fft_size
    nss: '2'
    ntx_gnb: '4'
    num_iter: '3'
    num_sc: sc_num
    num_ue: '2'
    numdatasyms: num_data_syms_p1+num_ctrl_syms_p1
    numltfsyms: '2'
    wideband: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    phase: '1'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_demapper_0_0_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    phase: '1'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_mapper_1_1
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    debug: 'False'
    ltfdata: '"../../data/su_mimo_he/2t2s/" + qam_type_p1 + "/ltf2x2_t1.bin"'
    mucpt: 'False'
    nstrm: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '-1'
  states: {}
- name: ncjt_rg_mapper_1_1_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    debug: 'False'
    ltfdata: '"../../data/su_mimo_he/2t2s/" + qam_type_p1 + "/ltf2x2_t2.bin"'
    mucpt: 'False'
    nstrm: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '-1'
  states: {}
- name: ncjt_sic_detect_0
  id: ncjt_sic_detect
  parameters:
    debug: 'False'
    modtype: qam_order_p1r
    ndatasymbols: num_data_syms_p1r + num_ctrl_syms_p1r
    nrx: '4'
    nss: '2'
    rgmode: rg_mode
  states: {}
- name: ncjt_skip_data_0_1_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*8
  states: {}
- name: ncjt_skip_data_0_1_1
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*8
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '6'
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type_p1 + "/ncjt_v2preamble.bin"'
    frmdatalen: tx_frame_len_p1
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '4'
    padding: '800'
    pktspersec: pkts_per_sec
    starttime: '2.0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"TxUE1 CSI-FB"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"TxUE2 CSI-FB"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 245.76e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 245.76e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_csi_fb_processing_0, cqi, ncjt_p1_precoding_0, cqi]
- [ncjt_csi_fb_processing_0, pmi, ncjt_p1_precoding_0, pmi]
- [ncjt_demapper_1, '0', blocks_null_sink_0, '0']
- [ncjt_demapper_1, '0', ncjt_csi_fb_processing_0, '0']
- [ncjt_demapper_1, '0', ncjt_err_stats_0, '0']
- [ncjt_demapper_1_0, '0', blocks_null_sink_0_0, '0']
- [ncjt_demapper_1_0, '0', ncjt_csi_fb_processing_0, '1']
- [ncjt_demapper_1_0, '0', ncjt_err_stats_1, '0']
- [ncjt_gnb_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_gnb_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_gnb_sync_0, '2', ncjt_ofdm_demod_0_2, '0']
- [ncjt_gnb_sync_0, '3', ncjt_ofdm_demod_0_1, '0']
- [ncjt_gnb_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_knobs_0, s_code_rate, ncjt_mapper_muxer_0_0, s_code_rate]
- [ncjt_knobs_0, s_modtypes, ncjt_mapper_muxer_0_0, s_modtypes]
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_1_1, '0']
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_1_1_0, '0']
- [ncjt_mu_chanest_0, '0', ncjt_sic_detect_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_sic_detect_0, '1']
- [ncjt_mu_chanest_0, '2', ncjt_sic_detect_0, '2']
- [ncjt_mu_chanest_0, '3', ncjt_sic_detect_0, '3']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0, '3']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0, '2']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_frm_ctrl_0, '2']
- [ncjt_ofdm_mod_0_0_1, '0', ncjt_tx_frm_ctrl_0, '3']
- [ncjt_p1_precoding_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_p1_precoding_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_p1_precoding_0, '2', ncjt_ofdm_mod_0_0_0, '0']
- [ncjt_p1_precoding_0, '3', ncjt_ofdm_mod_0_0_1, '0']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_demapper_1, '0']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_demapper_1, '1']
- [ncjt_rg_demapper_0_0_0_0, '0', ncjt_demapper_1_0, '0']
- [ncjt_rg_demapper_0_0_0_0, '1', ncjt_demapper_1_0, '1']
- [ncjt_rg_mapper_1_1, '0', ncjt_p1_precoding_0, '0']
- [ncjt_rg_mapper_1_1_0, '0', ncjt_p1_precoding_0, '1']
- [ncjt_sic_detect_0, '0', ncjt_rg_demapper_0_0_0, '0']
- [ncjt_sic_detect_0, '0', ncjt_skip_data_0_1_0_0, '0']
- [ncjt_sic_detect_0, '1', ncjt_rg_demapper_0_0_0_0, '0']
- [ncjt_sic_detect_0, '1', ncjt_skip_data_0_1_1, '0']
- [ncjt_skip_data_0_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_skip_data_0_1_1, '0', qtgui_const_sink_x_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_frm_ctrl_0, '2', uhd_usrp_sink_0, '2']
- [ncjt_tx_frm_ctrl_0, '3', uhd_usrp_sink_0, '3']
- [uhd_usrp_source_0, '0', ncjt_gnb_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_gnb_sync_0, '1']
- [uhd_usrp_source_0, '2', ncjt_gnb_sync_0, '2']
- [uhd_usrp_source_0, '3', ncjt_gnb_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
