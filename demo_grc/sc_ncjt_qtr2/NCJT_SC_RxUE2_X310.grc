options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_demo_rxue2_x310
    output_language: python
    title: NCJT Demo (RxUE2)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sd_num*num_data_syms*qam_order*nss
  states: {}
- name: frame_data_len_p2
  id: variable
  parameters:
    value: sd_num*num_data_syms_p2*qam_order
  states: {}
- name: frame_data_len_p3
  id: variable
  parameters:
    value: sd_num*num_data_syms_p3*qam_order
  states: {}
- name: frame_data_len_p3r
  id: variable
  parameters:
    value: sd_num*num_data_syms_p3r*qam_order*nss
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_ctrl_syms
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_ctrl_syms_p2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_ctrl_syms_p3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: num_data_syms_p2
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: num_data_syms_p3
  id: variable
  parameters:
    value: ncjt.RG_NUM_OFDM_SYM[rg_mode]
  states: {}
- name: num_data_syms_p3r
  id: variable
  parameters:
    value: '10'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '6'
  states: {}
- name: num_ltf_syms_p3r
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: ncjt.RG_NUM_DATA_SC[rg_mode]
  states: {}
- name: start_time_p2
  id: variable
  parameters:
    value: (0.25/pkts_per_sec)
  states: {}
- name: start_time_p3
  id: variable
  parameters:
    value: (0.5/pkts_per_sec)
  states: {}
- name: start_time_p3r
  id: variable
  parameters:
    value: (0.75/pkts_per_sec)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: usrp_address
  id: variable
  parameters:
    value: '"addr=192.168.40.2"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: ncjt_demapper_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rg_mode
  states: {state: disabled}
- name: ncjt_demapper_1_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rg_mode
  states: {}
- name: ncjt_demapper_1_0_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rg_mode
  states: {state: disabled}
- name: ncjt_err_stats_0
  id: ncjt_err_stats
  parameters:
    caption: Tx gNB Beacon
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {state: disabled}
- name: ncjt_err_stats_1
  id: ncjt_err_stats
  parameters:
    caption: Phase 2 Reception (RxUE2)
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_2
  id: ncjt_err_stats
  parameters:
    caption: Rx gNB to RxUE2
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {state: disabled}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '13'
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p3r
    npreamblesyms: num_ltf_syms_p3r
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_ltf_chanest_0_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'True'
    debug: 'True'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms + num_ctrl_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '4'
    removecs: 'False'
    rgmode: rg_mode
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '14'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms_p3r
    nrx: nss
    nss: nss
    rgmode: rg_mode
    showmaxllr: 'False'
  states: {}
- name: ncjt_mimo_detect_0_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms + num_ctrl_syms
    nrx: nss
    nss: nss
    rgmode: rg_mode
    showmaxllr: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '11'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms_p2+num_ctrl_syms_p2
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '10'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '10'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '11'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '13'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '11'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_1_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '13'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '15'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '15'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_remapper_muxer_1
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: '1'
    rgmode: rg_mode
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '10'
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    phase: '1'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '12'
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '1'
    phase: '2'
    rgmode: rg_mode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_1
  id: ncjt_rg_demapper
  parameters:
    affinity: '14'
    debug: 'False'
    minoutbuf: '32768'
    nstrm: '2'
    phase: '1'
    rgmode: rg_mode
    usecsi: 'False'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '14'
    debug: 'False'
    ltfdata: '"../../data/mu_mimo_he/2t2s/" + qam_type + "/ltf2x2_t2.bin"'
    minoutbuf: '32768'
    mucpt: 'True'
    nstrm: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '1'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    affinity: '9'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms+num_ctrl_syms)
    debug: 'False'
    hwdelayp2: '800'
    hwdelayp3: '780'
    lltf2: 'True'
    maxcorrlen: '2000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: (fft_size+cp_len)*(2+num_data_syms_p2+num_ctrl_syms_p2)
    p2preamblelen: (fft_size+cp_len)
    p2rx: 'True'
    p2start: start_time_p2
    p3framelen: (fft_size+cp_len)*(num_ltf_syms_p3r+num_data_syms_p3r)
    p3preamblelen: (fft_size+cp_len)
    p3rx: 'True'
    p3start: start_time_p3r
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_skip_data_0_1_0_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_skip_data_0_1_0_1
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '12'
    debug: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p2+num_ctrl_syms_p2
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '15'
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo_he/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    frmdatalen: (num_data_syms_p3+num_ctrl_syms_p3+2) * (fft_size+cp_len)
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '500'
    pktspersec: pkts_per_sec
    starttime: start_time_p3 + 5.0
  states: {}
- name: ncjt_ul_precoding_0
  id: ncjt_ul_precoding
  parameters:
    affinity: '14'
    csifile: ''
    debug: 'False'
    eigenmode: 'False'
    loadcsi: 'False'
    minoutbuf: '32768'
    ndatasyms: num_data_syms_p3 + num_ctrl_syms_p3
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    rgmode: rg_mode
    wideband: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    name: '"Rx gNB CSI-RS"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"Phase 2 Reception"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"Tx gNB Beacon"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '15'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '9'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_demapper_1, '0', ncjt_err_stats_0, '0']
- [ncjt_demapper_1_0, '0', ncjt_err_stats_1, '0']
- [ncjt_demapper_1_0, '0', ncjt_remapper_muxer_1, '0']
- [ncjt_demapper_1_0_0, '0', ncjt_err_stats_2, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_ltf_chanest_0, csi, ncjt_ul_precoding_0, csi]
- [ncjt_ltf_chanest_0_0, '0', ncjt_mimo_detect_0_0, '0']
- [ncjt_ltf_chanest_0_0, '1', ncjt_mimo_detect_0_0, '1']
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_1, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_1, '1']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_mimo_detect_0_0, '0', ncjt_skip_data_0_1_0_1, '0']
- [ncjt_mimo_detect_0_0, '1', blocks_null_sink_0, '0']
- [ncjt_mu_chanest_0_0_0, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_0_0, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0_0, '1']
- [ncjt_ofdm_demod_0_0_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0_0_0, '0']
- [ncjt_ofdm_demod_0_1_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_1, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_remapper_muxer_1, '0', ncjt_rg_mapper_0, '0']
- [ncjt_rg_demapper_0, '0', blocks_null_sink_2, '0']
- [ncjt_rg_demapper_0, '0', ncjt_demapper_1, '0']
- [ncjt_rg_demapper_0, '1', blocks_null_sink_2, '1']
- [ncjt_rg_demapper_0, '1', ncjt_demapper_1, '1']
- [ncjt_rg_demapper_0_0, '0', ncjt_demapper_1_0, '0']
- [ncjt_rg_demapper_0_0, '1', ncjt_demapper_1_0, '1']
- [ncjt_rg_demapper_1, '0', blocks_null_sink_1, '0']
- [ncjt_rg_demapper_1, '0', ncjt_demapper_1_0_0, '0']
- [ncjt_rg_demapper_1, '1', blocks_null_sink_1, '1']
- [ncjt_rg_demapper_1, '1', ncjt_demapper_1_0_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_ul_precoding_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0, '2', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0, '3', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_rx_sync_0, '4', ncjt_ofdm_demod_0_1_0, '0']
- [ncjt_rx_sync_0, '5', ncjt_ofdm_demod_0_0_0_0, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_frm_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_frm_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_skip_data_0_1_0_0, '0', qtgui_const_sink_x_0_1_0_0, '0']
- [ncjt_skip_data_0_1_0_1, '0', qtgui_const_sink_x_0_1_0_1, '0']
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_stbc_decode_0_0, '2', ncjt_skip_data_0_1_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_ul_precoding_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_ul_precoding_0, '1', ncjt_ofdm_mod_1, '0']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
