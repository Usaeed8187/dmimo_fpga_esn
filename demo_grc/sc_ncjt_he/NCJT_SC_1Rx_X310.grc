options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_1rx_x310_he
    output_language: python
    title: NCJT SC 1Rx X310 HE
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sd_num*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '14'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '30.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: sd_num
  id: variable
  parameters:
    value: '234'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr0=192.168.40.2"'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '4'
    debug: 'True'
    logfreq: '50'
    minoutbuf: '32768'
    mucpt: 'False'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: rg_mode
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: rg_mode
    symoffset: cp_len-4
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '6'
    avgwindow: '10'
    debug: 'True'
    filename: '"../../data/sc_ncjt_he/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    logpkterr: 'True'
    minoutbuf: '32768'
    nstrms: '1'
    shortterm: 'True'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '6'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    mergestrm: 'True'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    rgmode: rg_mode
    usecsi: 'True'
  states: {}
- name: ncjt_rx_sync_0_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.6'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'False'
    maxcorrlen: '2000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: '0'
    p2preamblelen: '0'
    p2rx: 'False'
    p2start: '0'
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_skip_data_0_1_0
  id: ncjt_skip_data
  parameters:
    debug: 'False'
    nstrm: '1'
    skiplen: sd_num*4
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: rg_mode
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '10'
    type: float
    update_time: '2'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '2'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_mu_chanest_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_pkt_err_0_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0, '1', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_rx_sync_0_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_skip_data_0_1_0, '0', qtgui_const_sink_x_0_1, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', ncjt_skip_data_0_1_0, '0']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
