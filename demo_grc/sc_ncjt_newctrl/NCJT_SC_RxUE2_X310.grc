options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_rxue1
    output_language: python
    title: NCJT Demo (Rx UE1)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: ntx+nss
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tx_frame_length
  id: variable
  parameters:
    value: (num_data_syms + 2) * (fft_size+cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '14.5'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.40.2"'
  states: {}
- name: ncjt_demapper_0
  id: ncjt_demapper
  parameters:
    affinity: '12'
    coded: 'True'
    debug: 'False'
    deterministic_input: 'True'
  states: {}
- name: ncjt_err_stats_0
  id: ncjt_err_stats
  parameters:
    caption: ''
    cols: '2'
    dark: 'False'
    debug: 'False'
    frame_per_sec: pkts_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'False'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    mcs: 'False'
    noair: 'False'
    reset: 'True'
  states: {}
- name: ncjt_ltf_chanest_0_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '10'
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: '0'
  states: {}
- name: ncjt_mapper_muxer_phase3_0
  id: ncjt_mapper_muxer_phase3
  parameters:
    affinity: '12'
    debug: 'False'
    n_ofdm_syms: '40'
    nstrm: '1'
    sd_num: '52'
    use_polar: 'True'
  states: {}
- name: ncjt_mimo_detect_0_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '10'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: nss
    nss: nss
    rgmode: '0'
    showmaxllr: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '11'
    debug: 'True'
    logfreq: '50'
    mucpt: 'False'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
    rgmode: '0'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '11'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_3
  id: ncjt_ofdm_demod
  parameters:
    affinity: '11'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '12'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '12'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: nss
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '11'
    code_rate: '0'
    debug: 'False'
    modtype: qam_order
    n_ofdm_syms: num_data_syms
    nstrm: '1'
    phase: '2'
    sd_num: '52'
    tag_snr: 'True'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '12'
    debug: 'False'
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2_t2.bin"'
    mucpt: 'True'
    n_ofdm_syms: num_data_syms
    nstrm: '1'
    numue: '2'
    pilot_sc_ind: '[7, 21, 34, 48]'
    sc_num: '56'
    ueidx: '1'
  states: {}
- name: ncjt_rx_sync_0_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '8'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '4000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: (fft_size+cp_len)*(2+num_data_syms)
    p2preamblelen: (fft_size+cp_len)*3
    p2rx: 'True'
    p2start: (0.25/pkts_per_sec)
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '12'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: '0'
  states: {}
- name: ncjt_tx_frm_ctrl_0_0
  id: ncjt_tx_frm_ctrl
  parameters:
    affinity: '13'
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    frmdatalen: tx_frame_length
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.75/pkts_per_sec) + 5.0
  states: {}
- name: ncjt_ul_precoding_0_0
  id: ncjt_ul_precoding
  parameters:
    affinity: '11'
    csifile: ''
    debug: 'False'
    eigenmode: 'True'
    loadcsi: 'False'
    ndatasyms: num_data_syms
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    rgmode: '0'
    wideband: 'True'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,2,2,2
    legend: 'False'
    name: '"gNB S2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    name: '"gNB S1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,4,2,2)
    legend: 'False'
    name: '"TxUE"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0_1_0_0
  id: uhd_usrp_sink
  parameters:
    affinity: '13'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    affinity: '8'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    clock_source0: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_demapper_0, '0', ncjt_err_stats_0, '0']
- [ncjt_demapper_0, '1', ncjt_mapper_muxer_phase3_0, '0']
- [ncjt_knobs_0, reset, ncjt_err_stats_0, reset]
- [ncjt_ltf_chanest_0_0, '0', ncjt_mimo_detect_0_0, '0']
- [ncjt_ltf_chanest_0_0, '1', ncjt_mimo_detect_0_0, '1']
- [ncjt_ltf_chanest_0_0, csi, ncjt_ul_precoding_0_0, csi]
- [ncjt_mapper_muxer_phase3_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_mimo_detect_0_0, '0', qtgui_const_sink_x_0_1, '0']
- [ncjt_mimo_detect_0_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_ltf_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_ltf_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_3, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_frm_ctrl_0_0, '1']
- [ncjt_ofdm_mod_0_1, '0', ncjt_tx_frm_ctrl_0_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_demapper_0, '0']
- [ncjt_rg_demapper_0, '1', ncjt_demapper_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_ul_precoding_0_0, '0']
- [ncjt_rx_sync_0_0, '0', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_rx_sync_0_0, '2', ncjt_ofdm_demod_0_3, '0']
- [ncjt_rx_sync_0_0, '3', ncjt_ofdm_demod_0_0_0_0, '0']
- [ncjt_rx_sync_0_0, rxrdy, ncjt_tx_frm_ctrl_0_0, txen]
- [ncjt_rx_sync_0_0, rxtime, ncjt_tx_frm_ctrl_0_0, rxtime]
- [ncjt_rx_sync_0_0, uhdcmd, uhd_usrp_source_0_0, command]
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_tx_frm_ctrl_0_0, '0', uhd_usrp_sink_0_1_0_0, '0']
- [ncjt_tx_frm_ctrl_0_0, '1', uhd_usrp_sink_0_1_0_0, '1']
- [ncjt_ul_precoding_0_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_ul_precoding_0_0, '1', ncjt_ofdm_mod_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', ncjt_rx_sync_0_0, '0']
- [uhd_usrp_source_0_0, '1', ncjt_rx_sync_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
