options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_gnb
    output_language: python
    title: NCJT Demo (gNB)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: is_deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_cols
  id: variable
  parameters:
    value: '3'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: repo_dir
  id: variable
  parameters:
    value: '"/home/ramin/dMIMO/dmimodemo/"'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: 100e4
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '45'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"mgmt0=192.168.60.2,addr0=192.168.60.2,mgmt1=192.168.40.2,addr1=192.168.40.2"'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s1.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s3.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s2.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_burst_tx_0_0_1
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/su_mimo/4t2s_csd/" + qam_type + "/txsig_s4.bin"'
    minoutbuf: '32768'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
    starttime: '2.0'
  states: {}
- name: ncjt_demapper_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: is_deterministic
  states: {}
- name: ncjt_demapper_0_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: is_deterministic
  states: {}
- name: ncjt_demapper_0_1_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: is_deterministic
  states: {}
- name: ncjt_demapper_0_2
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: is_deterministic
  states: {}
- name: ncjt_err_stats_0
  id: ncjt_err_stats
  parameters:
    caption: '"RxUE 1 (Copy #3)"'
    cols: num_cols
    dark: 'False'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (6, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_0_1
  id: ncjt_err_stats
  parameters:
    caption: '"N32x_1 (Copy #1)"'
    cols: num_cols
    dark: 'False'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (4, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_0_1_0
  id: ncjt_err_stats
  parameters:
    caption: '"N32x_2 (Copy #2)"'
    cols: num_cols
    dark: 'False'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (5, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_0_1_2
  id: ncjt_err_stats
  parameters:
    caption: HLL
    cols: num_cols
    dark: 'True'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (2, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'True'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_0_1_2_0
  id: ncjt_err_stats
  parameters:
    caption: Majority
    cols: num_cols
    dark: 'True'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (3, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'True'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_err_stats_0_2
  id: ncjt_err_stats
  parameters:
    caption: '"RxUE 2 (Copy #4)"'
    cols: num_cols
    dark: 'False'
    debug: 'False'
    frame_per_sec: '20'
    gui_hint: (7, 0, 1, 4)
    logfreq: '5'
    row_height: '300'
    show_birate: 'False'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'False'
    show_throughput: 'False'
    show_uncoded_ber: 'True'
  states: {}
- name: ncjt_gnb_sync_0
  id: ncjt_gnb_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    debug: 'False'
    hwdelayp2: '1735'
    hwdelayp3: '1735'
    maxcorrlen: '2000'
    nchans: '4'
    p2datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    p2preamblelen: (fft_size+cp_len)*3
    p2start: (0.25/pkts_per_sec)
    p3datalen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    p3preamblelen: (fft_size+cp_len)*3
    p3start: (0.75/pkts_per_sec)
    pktspersec: pkts_per_sec
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    gui_hint: (1, 0, 1, 4)
    mcs: 'False'
    noair: 'False'
    reset: 'True'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '7'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: '4'
    nss: '2'
    showmaxllr: 'False'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '7'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    mucpt: 'True'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '4'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '2'
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    mucpt: 'False'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
  states: {}
- name: ncjt_mu_chanest_0_1
  id: ncjt_mu_chanest
  parameters:
    affinity: '4'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    mucpt: 'False'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '1'
    removecs: 'True'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    affinity: '6'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_3
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_4
  id: ncjt_ofdm_demod
  parameters:
    affinity: '4'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pdc_1
  id: ncjt_pdc
  parameters:
    debug: 'False'
    deterministic_input: is_deterministic
    expire_ms: '5000'
    majority_enabled: 'True'
    num_copies: '4'
    num_threads: '0'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    code_rate: '0'
    debug: 'False'
    modtype: '2'
    n_ofdm_syms: '40'
    nstrm: '1'
    phase: '3'
    sd_num: '52'
    tag_snr: 'False'
    usecsi: 'False'
  states: {}
- name: ncjt_rg_demapper_0_1
  id: ncjt_rg_demapper
  parameters:
    code_rate: '0'
    debug: 'False'
    modtype: '2'
    n_ofdm_syms: '40'
    nstrm: '1'
    phase: '2'
    sd_num: '52'
    tag_snr: 'True'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_1_0
  id: ncjt_rg_demapper
  parameters:
    code_rate: '0'
    debug: 'False'
    modtype: '2'
    n_ofdm_syms: '40'
    nstrm: '1'
    phase: '2'
    sd_num: '52'
    tag_snr: 'True'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_2
  id: ncjt_rg_demapper
  parameters:
    code_rate: '0'
    debug: 'False'
    modtype: '2'
    n_ofdm_syms: '40'
    nstrm: '1'
    phase: '3'
    sd_num: '52'
    tag_snr: 'False'
    usecsi: 'False'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '3'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0, 2, 1, 1)
    legend: 'False'
    name: '"RxUE 1"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0, 3, 1, 1)
    legend: 'False'
    name: '"RxUE 2"'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0, 1, 1, 1)
    legend: 'False'
    name: '"N32x_2"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0, 0, 1, 1)
    legend: 'False'
    name: '"N32x_1"'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']
- [ncjt_burst_tx_0_0_0, '0', uhd_usrp_sink_0, '2']
- [ncjt_burst_tx_0_0_1, '0', uhd_usrp_sink_0, '3']
- [ncjt_demapper_0, '0', ncjt_err_stats_0, '0']
- [ncjt_demapper_0_1, '0', ncjt_err_stats_0_1, '0']
- [ncjt_demapper_0_1_0, '0', ncjt_err_stats_0_1_0, '0']
- [ncjt_demapper_0_2, '0', ncjt_err_stats_0_2, '0']
- [ncjt_gnb_sync_0, '0', ncjt_ofdm_demod_0_3, '0']
- [ncjt_gnb_sync_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_gnb_sync_0, '2', ncjt_ofdm_demod_0_4, '0']
- [ncjt_gnb_sync_0, '3', ncjt_ofdm_demod_0_0_1, '0']
- [ncjt_gnb_sync_0, '4', ncjt_ofdm_demod_0, '0']
- [ncjt_gnb_sync_0, '5', ncjt_ofdm_demod_0_0, '0']
- [ncjt_gnb_sync_0, '6', ncjt_ofdm_demod_0_2, '0']
- [ncjt_gnb_sync_0, '7', ncjt_ofdm_demod_0_1, '0']
- [ncjt_gnb_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_knobs_0, reset, ncjt_err_stats_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_1, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_1_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_1_2, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_1_2_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_2, reset]
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_0_2, '0']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [ncjt_mu_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mu_chanest_0, '2', ncjt_mimo_detect_0, '2']
- [ncjt_mu_chanest_0, '3', ncjt_mimo_detect_0, '3']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_1, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_1, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_1, '0', ncjt_mu_chanest_0_1, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0, '3']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0, '2']
- [ncjt_ofdm_demod_0_3, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_4, '0', ncjt_mu_chanest_0_1, '0']
- [ncjt_pdc_1, '0', ncjt_err_stats_0_1_2, '0']
- [ncjt_pdc_1, '1', ncjt_err_stats_0_1_2_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_demapper_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pdc_1, '2']
- [ncjt_rg_demapper_0, '1', ncjt_demapper_0, '1']
- [ncjt_rg_demapper_0, '1', ncjt_pdc_1, '6']
- [ncjt_rg_demapper_0_1, '0', ncjt_demapper_0_1, '0']
- [ncjt_rg_demapper_0_1, '0', ncjt_pdc_1, '0']
- [ncjt_rg_demapper_0_1, '1', ncjt_demapper_0_1, '1']
- [ncjt_rg_demapper_0_1, '1', ncjt_pdc_1, '4']
- [ncjt_rg_demapper_0_1_0, '0', ncjt_demapper_0_1_0, '0']
- [ncjt_rg_demapper_0_1_0, '0', ncjt_pdc_1, '1']
- [ncjt_rg_demapper_0_1_0, '1', ncjt_demapper_0_1_0, '1']
- [ncjt_rg_demapper_0_1_0, '1', ncjt_pdc_1, '5']
- [ncjt_rg_demapper_0_2, '0', ncjt_demapper_0_2, '0']
- [ncjt_rg_demapper_0_2, '0', ncjt_pdc_1, '3']
- [ncjt_rg_demapper_0_2, '1', ncjt_demapper_0_2, '1']
- [ncjt_rg_demapper_0_2, '1', ncjt_pdc_1, '7']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0_1, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0_1, '1']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_0_1_0_0, '0']
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_1_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_1_0, '1']
- [ncjt_stbc_decode_0_0, '2', qtgui_const_sink_x_0_1_0, '0']
- [uhd_usrp_source_0, '0', ncjt_gnb_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_gnb_sync_0, '1']
- [uhd_usrp_source_0, '2', ncjt_gnb_sync_0, '2']
- [uhd_usrp_source_0, '3', ncjt_gnb_sync_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
