options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_txue1
    output_language: python
    title: NCJT Demo (Tx UE)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ctrl_enabled
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: ntx+nss
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: tx_frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: tx_frame_length
  id: variable
  parameters:
    value: num_data_syms * (fft_size+cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '18'
  states: {}
- name: usrp_address
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/csi_data.bin
    type: complex
  states: {state: disabled}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    mcs: 'True'
    noair: 'False'
    reset: 'False'
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'True'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: nss
    ntx: ntx
    removecs: 'False'
    rgmode: '0'
  states: {}
- name: ncjt_mapper_muxer_0_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: '0'
    debug: 'False'
    deterministic_input: 'True'
    modtype: qam_order
    n_ofdm_syms: num_data_syms
    nstrm: '1'
    sd_num: '52'
    use_polar: 'True'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: '2'
    nss: '2'
    rgmode: '0'
    showmaxllr: 'False'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    minoutbuf: '32768'
    rgmode: '0'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: '0'
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    n_ofdm_syms: num_data_syms
    nstrm: '1'
    numue: '1'
    pilot_sc_ind: '[7, 21, 34, 48]'
    sc_num: '56'
    ueidx: '-1'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    hwdelayp2: '0'
    hwdelayp3: '0'
    lltf2: 'True'
    maxcorrlen: '2000'
    nchans: '2'
    p1rx: 'True'
    p2framelen: '0'
    p2preamblelen: '0'
    p2rx: 'False'
    p2start: (0.25/pkts_per_sec)
    p3framelen: '0'
    p3preamblelen: '0'
    p3rx: 'False'
    p3start: '0'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: '0'
    ueidx: '-1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/ncjt_preamble.bin"'
    frmdatalen: tx_frame_length
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.25/pkts_per_sec) + 5.0
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_address
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 184.32e6
    dev_addr: usrp_address
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_knobs_0, sel_code_rate, ncjt_mapper_muxer_0_0, sel_code_rate]
- [ncjt_knobs_0, sel_mod_type, ncjt_mapper_muxer_0_0, sel_mod_type]
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_ltf_chanest_0, csi, pdu_pdu_to_tagged_stream_0_0, pdus]
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_frm_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_frm_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
