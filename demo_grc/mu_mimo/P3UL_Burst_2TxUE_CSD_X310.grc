options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3ul_2txue_csd_x310
    output_language: python
    title: Phase 3 UL 2Tx UE (CSD)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: nss*sc_num*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: ntx+nss
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sc_num
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/mu_mimo/4t2s_csd/" + qam_type + "/txsig_s1.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/mu_mimo/4t2s_csd/" + qam_type + "/txsig_s3.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_1
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/mu_mimo/4t2s_csd/" + qam_type + "/txsig_s2.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_2
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../../data/mu_mimo/4t2s_csd/" + qam_type + "/txsig_s4.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source1: external
    dev_addr: '"addr0=192.168.30.2,addr1=192.168.40.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']
- [ncjt_burst_tx_0_1, '0', uhd_usrp_sink_0, '2']
- [ncjt_burst_tx_0_2, '0', uhd_usrp_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
