options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3ul_1txue_x310
    output_language: python
    title: Phase 3 UL 1Tx UE
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: nss*sc_data*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sc_data
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/mu_mimo/2t2s/" + qam_type + "/tx_strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    fftsize: '64'
    framelen: frame_data_len
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2.bin"'
    minoutbuf: '32768'
    mucpt: 'False'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: nss
    numue: '1'
    ueidx: '-1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms+2
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: '"addr0=192.168.30.2"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
