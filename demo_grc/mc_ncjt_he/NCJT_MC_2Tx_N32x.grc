options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_mc_2tx_n32x
    output_language: python
    title: NCJT MC 2Tx N32x
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: rg_fft_size[rg_mode]
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sc_data*num_data_syms*qam_order
  states: {}
- name: freq_comp_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_comp_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '14'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq_1
  id: variable
  parameters:
    value: 3.65e9 + freq_comp_1
  states: {}
- name: rf_freq_2
  id: variable
  parameters:
    value: 3.65e9 + freq_comp_2
  states: {}
- name: rg_fft_size
  id: variable
  parameters:
    value: '{0: 64, 1: 64, 2: 256, 3: 256, 4: 256, 5: 256, 6: 256, 7: 256}'
  states: {}
- name: rg_mode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sc_data
  id: variable
  parameters:
    value: '234'
  states: {}
- name: tx_frame_len
  id: variable
  parameters:
    value: num_data_syms * (fft_size + cp_len)
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '60'
    value: '45'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr0=192.168.40.2, addr1=192.168.60.2"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s1.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/strm_data_s2.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    minoutbuf: '32768'
    ntx: '2'
    rgmode: rg_mode
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    affinity: '1'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    ltfdata: ''
    mucpt: 'False'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '0'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    affinity: '1'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    framelen: frame_data_len
    ltfdata: ''
    mucpt: 'False'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    rgmode: rg_mode
    ueidx: '1'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: rg_mode
    ueidx: '0'
  states: {}
- name: ncjt_stbc_encode_0_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    rgmode: rg_mode
    ueidx: '1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/ncjt_v2preamble_ue1.bin"'
    frmdatalen: tx_frame_len
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2.0'
  states: {}
- name: ncjt_tx_frm_ctrl_0_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mc_ncjt_he/2t2s/" + qam_type + "/ncjt_v2preamble_ue2.bin"'
    frmdatalen: tx_frame_len
    fs: samp_rate
    minoutbuf: '32768'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '2'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq_1
    center_freq1: rf_freq_1
    center_freq2: rf_freq_2
    center_freq3: rf_freq_2
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_frm_ctrl_0_0, '0']
- [ncjt_ofdm_mod_0_0_1, '0', ncjt_tx_frm_ctrl_0_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_rg_mapper_0_0, '0', ncjt_stbc_encode_0_0, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_stbc_encode_0_0, '0', ncjt_ofdm_mod_0_0_0, '0']
- [ncjt_stbc_encode_0_0, '1', ncjt_ofdm_mod_0_0_1, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_frm_ctrl_0_0, '0', uhd_usrp_sink_0, '2']
- [ncjt_tx_frm_ctrl_0_0, '1', uhd_usrp_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
