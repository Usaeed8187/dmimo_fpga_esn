options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: dl_2rx_n320
    output_language: python
    title: Downlink 2Rx
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_length
  id: variable
  parameters:
    value: 2*52*num_data_syms
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_preamble_syms
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '1.0'
    step: '0.5'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/cpe_comp.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/csi_data.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'False'
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    removecs: 'False'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: '2'
    nss: '2'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '2'
    dataframelen: (fft_size+cp_len)*(2+num_data_syms)
    debug: 'False'
    maxcorrlen: '4000'
    minoutbuf: '32768'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*num_preamble_syms
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'True'
    filename: '"../data/2x2/64QAM/strm_data_2x2.bin"'
    logfreq: '50'
    nstrms: '2'
  states: {state: disabled}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'True'
    filename: '"../data/2x2/64QAM/tx_strm_data_2x2.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_qam_demapper_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: mod_order
    nstrms: '2'
    usecsi: 'False'
  states: {state: disabled}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    framelen: frame_length
    modtype: mod_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '2'
    usecsi: 'False'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"addr=192.168.40.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_ltf_chanest_0, cpe, pdu_pdu_to_tagged_stream_0, pdus]
- [ncjt_ltf_chanest_0, csi, pdu_pdu_to_tagged_stream_0_0, pdus]
- [ncjt_mimo_detect_0, '0', ncjt_qam_demapper_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_qam_demapper_0, '1']
- [ncjt_mimo_detect_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_pkt_detect_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_pkt_detect_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_pkt_err_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_qam_demapper_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_qam_demapper_0, '1', ncjt_pkt_err_0, '1']
- [ncjt_rg_demapper_0, '0', ncjt_pkt_err_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0_1_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
