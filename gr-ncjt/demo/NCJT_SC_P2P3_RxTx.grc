options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_p2p3_rxue1
    output_language: python
    title: NCJT SC RxUE 1
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"64QAM"'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 2.55e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: usrp_addr_1
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: usrp_addr_2
  id: variable
  parameters:
    value: '"addr=192.168.50.2"'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '2'
    debug: 'False'
    fftsize: fft_size
    logfreq: '10'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '10'
    debug: 'False'
    fftsize: fft_size
    logfreq: '10'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '9'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '5'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '5'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '11'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {state: disabled}
- name: ncjt_ofdm_mod_0_0_1
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '11'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {state: disabled}
- name: ncjt_ofdm_mod_0_2
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '5'
    berout: 'True'
    debug: 'True'
    filename: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_pkt_err_0_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '10'
    berout: 'True'
    debug: 'True'
    filename: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '3'
    debug: 'False'
    framelen: 52 * num_data_syms
    minoutbuf: '65536'
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '10'
    debug: 'False'
    framelen: 52 * num_data_syms
    minoutbuf: '65536'
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    affinity: '4'
    debug: 'False'
    framelen: frame_data_len
    minoutbuf: '65536'
    modtype: qam_order
    ndatasyms: int(num_data_syms/2)
    npilotsyms: '0'
    nstrms: '2'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    affinity: '11'
    debug: 'False'
    framelen: frame_data_len
    minoutbuf: '65536'
    modtype: qam_order
    ndatasyms: int(num_data_syms/2)
    npilotsyms: '0'
    nstrms: '2'
  states: {state: disabled}
- name: ncjt_rg_mapper_0_1
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    debug: 'False'
    framelen: frame_data_len
    minoutbuf: '65536'
    modtype: '6'
    ndatasyms: '20'
    npilotsyms: '0'
    nstrms: '2'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: (fft_size+cp_len)*(2+num_data_syms)
    debug: 'False'
    enablep3: 'False'
    gnbrx: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    samplerate: samp_rate
    xcorrthrd: '0.45'
  states: {}
- name: ncjt_rx_sync_0_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.6'
    affinity: '8'
    dataframelen: (fft_size+cp_len)*(2+num_data_syms)
    debug: 'False'
    enablep3: 'False'
    gnbrx: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    samplerate: samp_rate
    xcorrthrd: '0.45'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '3'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_stbc_decode_0_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_tx_framing_0
  id: ncjt_tx_framing
  parameters:
    affinity: '6'
    debug: 'False'
    filename: '"../data/2x2/" + modtype + "/preamble_2x2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: int(num_data_syms/2)
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.5/pkts_per_sec)+5
    txcal: 'False'
  states: {}
- name: ncjt_tx_framing_0_0
  id: ncjt_tx_framing
  parameters:
    affinity: '12'
    debug: 'False'
    filename: '"../data/2x2/" + modtype + "/preamble_2x2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: int(num_data_syms/2)
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '3.0'
    txcal: 'False'
  states: {state: disabled}
- name: ncjt_tx_framing_0_1
  id: ncjt_tx_framing
  parameters:
    debug: 'False'
    filename: '"../data/2x2/" + modtype + "/preamble_2x2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: '20'
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.5/pkts_per_sec)+5
    txcal: 'False'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2,2,2)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    color2: blue
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,4)
    label1: LMMSE
    label2: Rx2
    legend: 'False'
    nconnections: '2'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    width2: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '6'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: usrp_addr_1
    gain0: tx_gain-10
    gain1: tx_gain-10
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    affinity: '12'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: tx_freq
    center_freq1: tx_freq
    clock_rate: 200e6
    dev_addr: usrp_addr_2
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_1
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: tx_freq
    center_freq1: tx_freq
    clock_rate: 200e6
    dev_addr: '"addr=192.168.50.2"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: '"addr0=192.168.30.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    affinity: '8'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: usrp_addr_2
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_mu_chanest_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_mu_chanest_0_0, '0', ncjt_stbc_decode_0_0, '0']
- [ncjt_mu_chanest_0_0, '1', ncjt_stbc_decode_0_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_framing_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_framing_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_framing_0_0, '1']
- [ncjt_ofdm_mod_0_0_1, '0', ncjt_tx_framing_0_1, '1']
- [ncjt_ofdm_mod_0_1, '0', ncjt_tx_framing_0_0, '0']
- [ncjt_ofdm_mod_0_2, '0', ncjt_tx_framing_0_1, '0']
- [ncjt_pkt_err_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1_0, '0']
- [ncjt_pkt_err_0_0_0, '1', qtgui_time_sink_x_0, '1']
- [ncjt_pkt_err_0_0_0, '1', qtgui_time_sink_x_0_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_pkt_err_0_0_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_rg_mapper_0_1, '0']
- [ncjt_rg_mapper_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_rg_mapper_0_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_rg_mapper_0_0, '1', ncjt_ofdm_mod_0_0_0, '0']
- [ncjt_rg_mapper_0_1, '0', ncjt_ofdm_mod_0_2, '0']
- [ncjt_rg_mapper_0_1, '1', ncjt_ofdm_mod_0_0_1, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_framing_0, txen]
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_framing_0_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_framing_0, rxtime]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_framing_0_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_rx_sync_0_0, '0', ncjt_ofdm_demod_0_1, '0']
- [ncjt_rx_sync_0_0, '1', ncjt_ofdm_demod_0_0_0, '0']
- [ncjt_rx_sync_0_0, uhdcmd, uhd_usrp_source_0_0, command]
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_0_1, '0']
- [ncjt_stbc_decode_0_0, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_stbc_decode_0_0, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_stbc_decode_0_0, '2', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_tx_framing_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_framing_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_framing_0_0, '0', uhd_usrp_sink_0_0, '0']
- [ncjt_tx_framing_0_0, '1', uhd_usrp_sink_0_0, '1']
- [ncjt_tx_framing_0_1, '0', uhd_usrp_sink_0_1, '0']
- [ncjt_tx_framing_0_1, '1', uhd_usrp_sink_0_1, '1']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']
- [uhd_usrp_source_0_0, '0', ncjt_rx_sync_0_0, '0']
- [uhd_usrp_source_0_0, '1', ncjt_rx_sync_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
