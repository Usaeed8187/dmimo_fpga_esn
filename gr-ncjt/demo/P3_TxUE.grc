options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3_txue_x310
    output_language: python
    title: P3 TxUE X310
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*nss*num_data_syms*mod_order
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '8'
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"256QAM"'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.55e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/2x2/" + modtype + "/tx_strm_data_2x2.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    debug: 'False'
    framelen: frame_data_len
    minoutbuf: '65536'
    modtype: mod_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '2'
  states: {}
- name: ncjt_tx_framing_0
  id: ncjt_tx_framing
  parameters:
    debug: 'False'
    filename: '"../data/2x4/null_preamble_2x2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    ntx: '4'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2'
    txcal: 'False'
  states: {}
- name: ncjt_ul_precoding_0
  id: ncjt_ul_precoding
  parameters:
    debug: 'False'
    dl_nrx: '2'
    dl_ntx: '4'
    eigenmode: 'False'
    ndatasyms: num_data_syms
    nprecodedsyms: num_data_syms
    nss: '1'
    numhtsyms: '0'
    ul_ntx: '2'
  states: {}
- name: ncjt_ul_precoding_0_0
  id: ncjt_ul_precoding
  parameters:
    debug: 'False'
    dl_nrx: '2'
    dl_ntx: '4'
    eigenmode: 'False'
    ndatasyms: num_data_syms
    nprecodedsyms: num_data_syms
    nss: '1'
    numhtsyms: '0'
    ul_ntx: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: '0'
    center_freq3: '0'
    clock_rate: 200e6
    clock_source1: external
    dev_addr: '"addr0=192.168.30.2, addr1=192.168.50.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: '0'
    gain3: '0'
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_framing_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_framing_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_framing_0, '3']
- [ncjt_ofdm_mod_0_1, '0', ncjt_tx_framing_0, '2']
- [ncjt_rg_mapper_0, '0', ncjt_ul_precoding_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_ul_precoding_0_0, '0']
- [ncjt_tx_framing_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_framing_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_framing_0, '2', uhd_usrp_sink_0, '2']
- [ncjt_tx_framing_0, '3', uhd_usrp_sink_0, '3']
- [ncjt_ul_precoding_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_ul_precoding_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_ul_precoding_0_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_ul_precoding_0_0, '1', ncjt_ofdm_mod_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
