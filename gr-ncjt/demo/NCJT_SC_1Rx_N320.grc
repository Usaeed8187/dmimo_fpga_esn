options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_1rx_n320
    output_language: python
    title: NCJT SC 1Rx N320
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_preamble_syms
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.55e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0.0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s2.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s1.bin"'
    type: complex
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '4'
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'True'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '14'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '14'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '2'
    dataframelen: (fft_size+cp_len)*(2+num_data_syms)
    debug: 'False'
    maxcorrlen: '4000'
    minoutbuf: '32768'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*num_preamble_syms
    rxpwrthrd: '5e-4'
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '6'
    berout: 'True'
    debug: 'True'
    filename: '"../../data/sc_ncjt/1t1s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    affinity: '6'
    debug: 'False'
    framelen: 52 * num_data_syms
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    outputsyms: 'False'
    usecsi: 'True'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '2'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: internal
    dev_addr: '"addr=192.168.40.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_mu_chanest_0, '0', blocks_file_sink_0_1, '0']
- [ncjt_mu_chanest_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', blocks_file_sink_0_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_pkt_detect_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_pkt_detect_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_pkt_err_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_0_1_0, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
