options:
  parameters:
    generate_options: qt_gui
    id: LDPC_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: num_codeword_bit
  id: variable
  parameters:
    value: '6016'
  states: {}
- name: num_message_bit
  id: variable
  parameters:
    value: '4512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '9024'
  states: {}
- name: sigma
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sigma
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pdu_decoded.bin
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pdu_uncoded.bin
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2/(sigma*sigma)'
    type: float
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: ncjt_srsran_ldpc_decoder_0
  id: ncjt_srsran_ldpc_decoder
  parameters:
    codeword_length: num_codeword_bit
    debug: 'False'
    is_output_byte: 'False'
    message_length: num_message_bit
    mod: BPSK
  states: {}
- name: ncjt_srsran_ldpc_encoder_0
  id: ncjt_srsran_ldpc_encoder
  parameters:
    codeword_length: num_codeword_bit
    debug: 'False'
    is_input_byte: 'False'
    maxoutbuf: '65366'
    message_length: num_message_bit
    mod: BPSK
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: int(num_message_bit)
    mask: '0x01'
    maxsize: int(num_message_bit)
    minsize: int(num_message_bit)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: BER
    size: '5000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', ncjt_srsran_ldpc_decoder_0, '0']
- [blocks_xor_xx_0, '0', blocks_char_to_float_1, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', blocks_file_sink_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', blocks_xor_xx_0, '1']
- [ncjt_srsran_ldpc_encoder_0, '0', blocks_char_to_float_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_xor_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', ncjt_srsran_ldpc_encoder_0, '0']
- [pdu_random_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
