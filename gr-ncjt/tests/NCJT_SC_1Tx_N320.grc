options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_1tx_n320
    output_language: python
    title: NCJT SC 1Tx N320
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"64QAM"'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '40'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: repeat_duration
  id: variable
  parameters:
    value: 1.0/pkts_per_sec
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '45'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    affinity: '1'
    debug: 'False'
    framelen: frame_data_len
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_tx_framing_0
  id: ncjt_tx_framing
  parameters:
    affinity: '2'
    debug: 'False'
    filename: '"../data/1x1/ncjt_preamble_1x1.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2'
    txcal: 'False'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '2'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"addr0=192.168.60.2"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_framing_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_framing_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_tx_framing_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_framing_0, '1', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
