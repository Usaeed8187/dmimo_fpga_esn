options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_sc_ncjt_1tx
    output_language: python
    title: SC-NCJT Tx
  states: {}

blocks:
- name: pkt_size
  id: variable
  parameters:
    value: '7760'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '70'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    affinity: '1'
    debug: 'False'
    filename: '"../data/ncjt_tx1.bin"'
    minoutbuf: '65536'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    affinity: '1'
    debug: 'False'
    filename: '"../data/ncjt_tx2.bin"'
    minoutbuf: '65536'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 20e6
    dev_addr: ''
    dev_args: '"serial=32342BB"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
