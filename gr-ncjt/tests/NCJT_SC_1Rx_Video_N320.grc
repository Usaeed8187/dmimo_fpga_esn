options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_sc_1rx_video_n320
    output_language: python
    title: NCJT SC 1Rx Video
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"64QAM"'
  states: {}
- name: num_codeword_bit
  id: variable
  parameters:
    value: frame_data_len
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '30'
  states: {}
- name: num_message_bit
  id: variable
  parameters:
    value: '7520'
  states: {}
- name: num_preamble_syms
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.55e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '1.0'
    step: '0.5'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sigma
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.05'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
  states: {}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_csi.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/(sigma*sigma)
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: dMIMOStreamer_UdpSink_0
  id: dMIMOStreamer_UdpSink
  parameters:
    dest_ip: 127.0.0.1
    dest_port: '9999'
    pkt_size: '1316'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    debug: 'False'
    fftsize: '64'
    logfreq: '10'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '2'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '2'
    dataframelen: (fft_size+cp_len)*(2+num_data_syms)
    debug: 'False'
    maxcorrlen: '4000'
    minoutbuf: '32768'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*num_preamble_syms
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    affinity: '6'
    berout: 'True'
    debug: 'True'
    filename: '"../data/random_bytes.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    framelen: 52 * num_data_syms
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_srsran_ldpc_decoder_0
  id: ncjt_srsran_ldpc_decoder
  parameters:
    codeword_length: num_codeword_bit
    debug: 'False'
    is_output_byte: 'True'
    message_length: num_message_bit
    mod: BPSK
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_video_sink_0
  id: ncjt_video_sink
  parameters:
    debug: 'True'
    framelen: int(num_message_bit/8)
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (2,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: gpsdo
    dev_addr: '"addr=192.168.40.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', ncjt_srsran_ldpc_decoder_0, '0']
- [ncjt_mu_chanest_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_pkt_detect_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_pkt_detect_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_pkt_err_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_rg_demapper_0, '0', blocks_char_to_float_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', blocks_null_sink_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', dMIMOStreamer_UdpSink_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', ncjt_video_sink_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', blocks_file_sink_0_1_0_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_video_sink_0, '0', dMIMOStreamer_UdpSink_0, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
