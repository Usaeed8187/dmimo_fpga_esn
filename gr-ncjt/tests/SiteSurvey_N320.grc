options:
  parameters:
    author: Donald
    generate_options: qt_gui
    id: sitesurvey_n320
    output_language: python
    title: Site Survey
  states: {}

blocks:
- name: rf_freq
  id: variable
  parameters:
    value: 3.55e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '1.0'
    step: '0.5'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: blocks_file_sink_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/rx_data_d.bin
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '20'
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    center_freq0: rf_freq
    clock_rate: 200e6
    dev_addr: '"addr=192.168.80.2"'
    gain0: rx_gain
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [fir_filter_xxx_0, '0', blocks_file_sink_0_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-80-g0e28fd53
