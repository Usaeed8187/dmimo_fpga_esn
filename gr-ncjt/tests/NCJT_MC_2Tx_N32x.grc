options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ncjt_mc_2tx_x310
    output_language: python
    title: NCJT MC 2Tx X310
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 2*52*num_data_syms*qam_order
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"16QAM"'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: repeat_duration
  id: variable
  parameters:
    value: 1.0/pkts_per_sec
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '35'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/2x2/" + modtype + "/strm_data_2x2.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    affinity: '1'
    debug: 'False'
    framelen: frame_data_len
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '2'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_stbc_encode_0_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_tx_framing_0
  id: ncjt_tx_framing
  parameters:
    affinity: '2'
    debug: 'False'
    duration: repeat_duration
    filename: '"../data/2x2/ncjt_preamble_2x2_ue1.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    nstrm: '2'
    padding: '1000'
    starttime: '2'
  states: {}
- name: ncjt_tx_framing_0_0
  id: ncjt_tx_framing
  parameters:
    affinity: '2'
    debug: 'False'
    duration: repeat_duration
    filename: '"../data/2x2/ncjt_preamble_2x2_ue2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    nstrm: '2'
    padding: '1000'
    starttime: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '2'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.60.2, addr1=192.168.40.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_framing_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_framing_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_framing_0_0, '0']
- [ncjt_ofdm_mod_0_0_1, '0', ncjt_tx_framing_0_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_stbc_encode_0_0, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_stbc_encode_0_0, '0', ncjt_ofdm_mod_0_0_0, '0']
- [ncjt_stbc_encode_0_0, '1', ncjt_ofdm_mod_0_0_1, '0']
- [ncjt_tx_framing_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_framing_0, '1', uhd_usrp_sink_0, '1']
- [ncjt_tx_framing_0_0, '0', uhd_usrp_sink_0, '2']
- [ncjt_tx_framing_0_0, '1', uhd_usrp_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
