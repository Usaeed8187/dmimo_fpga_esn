options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_mumimo_rx_n321
    output_language: python
    title: Test MU-MIMO Uplink (RX)
  states: {}

blocks:
- name: dataframe_len
  id: variable
  parameters:
    value: (256+64)*18
  states: {}
- name: nrx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: 3*80
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_frames_s1.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_frames_s2.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_frames_s3.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_2
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_frames_s4.bin"'
    type: complex
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.65'
    dataframelen: dataframe_len
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '4'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.45'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: gpsdo
    clock_source1: gpsdo
    dev_args: '"addr0=192.168.60.2,addr1=192.168.40.2"'
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: gpsdo
    time_source1: gpsdo
    type: fc32
  states: {}

connections:
- [ncjt_pkt_detect_0, '0', blocks_file_sink_0_0_1, '0']
- [ncjt_pkt_detect_0, '1', blocks_file_sink_0_0_1_0, '0']
- [ncjt_pkt_detect_0, '2', blocks_file_sink_0_0_1_1, '0']
- [ncjt_pkt_detect_0, '3', blocks_file_sink_0_0_1_2, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']
- [uhd_usrp_source_0, '2', ncjt_pkt_detect_0, '2']
- [uhd_usrp_source_0, '3', ncjt_pkt_detect_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
