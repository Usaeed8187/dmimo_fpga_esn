options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_stbc
    output_language: python
    title: Test STBC Tx/Rx
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*num_data_syms*qam_order
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"64QAM"'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e5
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/data_frame.bin"'
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s2.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s1.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_out.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_csi.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_1_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_s1.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_s2.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_1_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_tx1.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_1_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/stbc_tx2.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: ncjt_add_preamble_0
  id: ncjt_add_preamble
  parameters:
    affinity: '2'
    debug: 'False'
    filename: '"../data/2x2/htltfx.bin"'
    nstrms: '2'
  states: {}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    debug: 'False'
    fftsize: '64'
    logfreq: '10'
    ndatasyms: num_data_syms
    npreamblesyms: '2'
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'True'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '2'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: '2'
    scaling: '0.5'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'False'
    debug: 'True'
    filename: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    logfreq: '1'
    nstrms: '1'
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    framelen: 52 * num_data_syms
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrm: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    affinity: '1'
    debug: 'False'
    framelen: frame_data_len
    modtype: qam_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
  states: {}
- name: ncjt_stbc_decode_0
  id: ncjt_stbc_decode
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: ncjt_stbc_encode_0
  id: ncjt_stbc_encode
  parameters:
    affinity: '1'
    debug: 'False'
    fftsize: fft_size
    ndatasyms: num_data_syms
    npilotsyms: '0'
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [ncjt_add_preamble_0, '0', blocks_file_sink_0_1_1_1, '0']
- [ncjt_add_preamble_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_add_preamble_0, '1', blocks_file_sink_0_1_1_1_0, '0']
- [ncjt_add_preamble_0, '1', ncjt_ofdm_demod_1, '0']
- [ncjt_mu_chanest_0, '0', blocks_file_sink_0_1, '0']
- [ncjt_mu_chanest_0, '0', ncjt_stbc_decode_0, '0']
- [ncjt_mu_chanest_0, '1', blocks_file_sink_0_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_stbc_decode_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_1, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_add_preamble_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_add_preamble_0, '1']
- [ncjt_pkt_err_0_0, '0', blocks_null_sink_0, '0']
- [ncjt_rg_demapper_0, '0', blocks_file_sink_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_rg_mapper_0, '0', ncjt_stbc_encode_0, '0']
- [ncjt_stbc_decode_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_stbc_decode_0, '1', blocks_file_sink_0_1_0_0, '0']
- [ncjt_stbc_decode_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_stbc_decode_0, '2', blocks_file_sink_0_1_0, '0']
- [ncjt_stbc_decode_0, '2', qtgui_const_sink_x_0_1_0, '0']
- [ncjt_stbc_encode_0, '0', blocks_file_sink_0_1_1, '0']
- [ncjt_stbc_encode_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_stbc_encode_0, '1', blocks_file_sink_0_1_1_0, '0']
- [ncjt_stbc_encode_0, '1', ncjt_ofdm_mod_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
