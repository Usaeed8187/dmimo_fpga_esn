options:
  parameters:
    generate_options: qt_gui
    id: fpga_connection_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frame_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''../../data/debug.txt'''
    type: float
    vlen: '2'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: frame_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: frame_len
    type: float
  states: {state: disabled}
- name: ncjt_esn_fpga_bridge_0
  id: ncjt_esn_fpga_bridge
  parameters:
    bind_to_data_port: 'False'
    data_port: '5001'
    default_weights: None
    fpga_ip: 192.168.1.10
    fpga_replies_path: ../../data/nmses.txt
    fpga_reply_mode: batch
    frame_len: frame_len
    length_tag_key: packet_len
    npz_key: '''H_real_imag'''
    npz_path: '''../../data/H_real_imag_filtered_float64.npz'''
    out_len: '2'
    output_format: int16
    q15_scale: '32767.0'
    read_from_file: 'True'
    reply_every_n_transmissions: '40'
    save_fpga_replies: 'True'
    socket_timeout_ms: '180000'
    terminate_after_n_transmissions: 'True'
    update_weights_each_packet: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: frame_len
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: frame_len
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_stream_to_vector_0, '0', ncjt_esn_fpga_bridge_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [ncjt_esn_fpga_bridge_0, '0', blocks_file_sink_0, '0']
- [ncjt_esn_fpga_bridge_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
