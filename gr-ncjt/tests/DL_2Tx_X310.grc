options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: dl_2tx_x310
    output_language: python
    title: DL_2Tx_X310
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*nss*num_data_syms*mod_order
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '8'
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"256QAM"'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: repeat_duration
  id: variable
  parameters:
    value: 1.0/pkts_per_sec
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.55e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: scaling_16qam
  id: variable
  parameters:
    value: '0.481730686153750'
  states: {}
- name: scaling_256qam
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: scaling_64qam
  id: variable
  parameters:
    value: '0.531729451315402'
  states: {}
- name: scaling_qpsk
  id: variable
  parameters:
    value: '0.560940733177977'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rgsig_s1.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rgsig_s2.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/2x2/" + modtype + "/tx_strm_data_2x2.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../data/2x2/" + modtype + "/txdsyms_2x2_s1.bin"'
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: '"../data/2x2/" + modtype + "/txdsyms_2x2_s2.bin"'
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 56*num_data_syms
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 56*num_data_syms
    type: complex
  states: {state: disabled}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: scaling_256qam
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: scaling_256qam
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    debug: 'False'
    framelen: frame_data_len
    minoutbuf: '65536'
    modtype: mod_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '2'
  states: {}
- name: ncjt_tx_framing_0
  id: ncjt_tx_framing
  parameters:
    debug: 'False'
    filename: '"../data/2x2/" + modtype + "/preamble_2x2.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '2'
    txcal: 'False'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: '"addr=192.168.30.2"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_ofdm_mod_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', ncjt_ofdm_mod_0_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_framing_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_framing_0, '1']
- [ncjt_rg_mapper_0, '0', blocks_file_sink_0, '0']
- [ncjt_rg_mapper_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_rg_mapper_0, '1', blocks_file_sink_0_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_tx_framing_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_framing_0, '1', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
