options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_sc_ncjt_6rx_sync
    output_language: python
    title: SC-NCJT Rx
  states: {}

blocks:
- name: lo_off
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: pkt_size
  id: variable
  parameters:
    value: 320*18
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '16'
  states: {}
- name: rx_gain_2
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: rx_gain_n320
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s1.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s2.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s3.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_2
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s4.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_3
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s5.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_4
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s6.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_5
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s7.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_6
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s8.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_7
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s9.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_8
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s10.bin"'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_8_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s11.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_8_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s12.bin"'
    type: complex
  states: {state: disabled}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_detect_0_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_detect_0_1
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_detect_0_2
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_detect_0_3
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_detect_0_3_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {state: disabled}
- name: ncjt_sync_all_0
  id: ncjt_sync_all
  parameters:
    debug: 'True'
    num_rx: '5'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    ant4: '"TX/RX"'
    ant5: '"TX/RX"'
    ant6: '"TX/RX"'
    ant7: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    center_freq4: rf_freq
    center_freq5: rf_freq
    center_freq6: rf_freq
    center_freq7: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    clock_source2: external
    clock_source3: external
    dev_addr: '"addr0=192.168.30.2,addr1=192.168.40.2,addr2=192.168.50.2,addr3=192.168.60.2"'
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    gain4: rx_gain
    gain5: rx_gain
    gain6: rx_gain_2
    gain7: rx_gain_2
    nchan: '8'
    num_mboards: '4'
    rx_agc2: Default
    rx_agc3: Default
    rx_agc4: Default
    rx_agc5: Default
    rx_agc6: Default
    rx_agc7: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    time_source2: external
    time_source3: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"type=n3xx,mgmt_addr=192.168.80.2,addr=192.168.80.2"'
    gain0: rx_gain_n320
    gain1: rx_gain_n320
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_pkt_detect_0, '0', blocks_file_sink_0_0_1, '0']
- [ncjt_pkt_detect_0, '1', blocks_file_sink_0_0_1_0, '0']
- [ncjt_pkt_detect_0, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_pkt_detect_0_0, '0', blocks_file_sink_0_0_1_1, '0']
- [ncjt_pkt_detect_0_0, '1', blocks_file_sink_0_0_1_2, '0']
- [ncjt_pkt_detect_0_0, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_pkt_detect_0_1, '0', blocks_file_sink_0_0_1_3, '0']
- [ncjt_pkt_detect_0_1, '1', blocks_file_sink_0_0_1_4, '0']
- [ncjt_pkt_detect_0_1, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_pkt_detect_0_2, '0', blocks_file_sink_0_0_1_5, '0']
- [ncjt_pkt_detect_0_2, '1', blocks_file_sink_0_0_1_6, '0']
- [ncjt_pkt_detect_0_2, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_pkt_detect_0_3, '0', blocks_file_sink_0_0_1_7, '0']
- [ncjt_pkt_detect_0_3, '1', blocks_file_sink_0_0_1_8, '0']
- [ncjt_pkt_detect_0_3, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_pkt_detect_0_3_0, '0', blocks_file_sink_0_0_1_8_0, '0']
- [ncjt_pkt_detect_0_3_0, '1', blocks_file_sink_0_0_1_8_1, '0']
- [ncjt_pkt_detect_0_3_0, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0, allrdy]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0_0, allrdy]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0_1, allrdy]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0_2, allrdy]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0_3, allrdy]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0_3_0, allrdy]
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']
- [uhd_usrp_source_0, '2', ncjt_pkt_detect_0_0, '0']
- [uhd_usrp_source_0, '3', ncjt_pkt_detect_0_0, '1']
- [uhd_usrp_source_0, '4', ncjt_pkt_detect_0_1, '0']
- [uhd_usrp_source_0, '5', ncjt_pkt_detect_0_1, '1']
- [uhd_usrp_source_0, '6', ncjt_pkt_detect_0_2, '0']
- [uhd_usrp_source_0, '7', ncjt_pkt_detect_0_2, '1']
- [uhd_usrp_source_0_0, '0', ncjt_pkt_detect_0_3, '0']
- [uhd_usrp_source_0_0, '1', ncjt_pkt_detect_0_3, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-80-g0e28fd53
