options:
  parameters:
    generate_options: qt_gui
    id: streamer_ldpc_test
    output_language: python
    title: Streamer LDPC Test
  states: {}

blocks:
- name: num_codeword_bit
  id: variable
  parameters:
    value: '6016'
  states: {}
- name: num_message_bit
  id: variable
  parameters:
    value: '4512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sigma
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: sigma
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/video.ts"'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-2/(sigma*sigma)'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(num_message_bit/8)
    type: byte
  states: {state: disabled}
- name: dMIMOStreamer_UdpSink_0
  id: dMIMOStreamer_UdpSink
  parameters:
    dest_ip: 127.0.0.1
    dest_port: '9999'
    pkt_size: '1316'
  states: {}
- name: dMIMOStreamer_UdpSource_0
  id: dMIMOStreamer_UdpSource
  parameters:
    mcast_grp: 239.255.0.1
    mcast_port: '1234'
  states: {}
- name: ncjt_srsran_ldpc_decoder_0
  id: ncjt_srsran_ldpc_decoder
  parameters:
    codeword_length: num_codeword_bit
    debug: 'False'
    is_output_byte: 'True'
    message_length: num_message_bit
    mod: BPSK
  states: {}
- name: ncjt_srsran_ldpc_encoder_0
  id: ncjt_srsran_ldpc_encoder
  parameters:
    codeword_length: num_codeword_bit
    debug: 'True'
    is_input_byte: 'True'
    maxoutbuf: '65366'
    message_length: num_message_bit
    mod: BPSK
  states: {}
- name: ncjt_video_sink_0
  id: ncjt_video_sink
  parameters:
    debug: 'False'
    framelen: int(num_message_bit/8)
  states: {state: disabled}
- name: ncjt_video_source_0
  id: ncjt_video_source
  parameters:
    debug: 'False'
    framelen: int(num_message_bit/8)
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', ncjt_srsran_ldpc_decoder_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_srsran_ldpc_encoder_0, '0']
- [dMIMOStreamer_UdpSource_0, '0', blocks_file_sink_0, '0']
- [dMIMOStreamer_UdpSource_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [dMIMOStreamer_UdpSource_0, '0', ncjt_video_source_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', dMIMOStreamer_UdpSink_0, '0']
- [ncjt_srsran_ldpc_decoder_0, '0', ncjt_video_sink_0, '0']
- [ncjt_srsran_ldpc_encoder_0, '0', blocks_char_to_float_0, '0']
- [ncjt_video_sink_0, '0', dMIMOStreamer_UdpSink_0, '0']
- [ncjt_video_source_0, '0', ncjt_srsran_ldpc_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
