options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_mimo_sic_detect_4rx
    output_language: python
    title: MIMO SIC Detect 4Rx
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_length
  id: variable
  parameters:
    value: 80*(40+2)
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_preamble_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e4
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/dl_chanest_s1.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/dl_chanest_s2.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
    vlen: '2'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/dl_chanest_s3.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s1.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/chanest_s2.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: '"/tmp/dl_chanest_s4.bin"'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../testdata/try2/rx_data_s1.bin"'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../testdata/try2/rx_data_s2.bin"'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: '"../testdata/try2/rx_data_s3.bin"'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: '"../testdata/try2/rx_data_s4.bin"'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame_start"'
    packet_len: frame_length
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame_start"'
    packet_len: frame_length
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame_start"'
    packet_len: frame_length
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"frame_start"'
    packet_len: frame_length
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'False'
    debug: 'True'
    fftsize: fft_size
    logfreq: '20'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_preamble_syms
    nrx: '4'
    ntx: '2'
  states: {}
- name: ncjt_ltf_chanest_0_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'False'
    debug: 'False'
    fftsize: fft_size
    logfreq: '20'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_preamble_syms
    nrx: '2'
    ntx: '2'
  states: {state: disabled}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    debug: 'False'
    fftsize: fft_size
    logfreq: '10'
    ndatasymbols: num_data_syms
    nrx: '4'
    nss: '2'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../data/16QAM/strm_data_2x2.bin"'
    logfreq: '20'
    nstrms: '2'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'True'
    filename: '"../data/16QAM/strm_data_2x2.bin"'
    logfreq: '20'
    nstrms: '2'
  states: {}
- name: ncjt_qam_demapper_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: '4'
    nstrms: '2'
    usecsi: 'False'
  states: {}
- name: ncjt_qam_demapper_0_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: '4'
    nstrms: '2'
    usecsi: 'False'
  states: {}
- name: ncjt_sic_detect_0
  id: ncjt_sic_detect
  parameters:
    debug: 'False'
    fftsize: fft_size
    modtype: '4'
    ndatasymbols: num_data_syms
    nrx: '4'
    nss: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '1024'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.75'
    autoscale: 'True'
    color2: dark red
    entags: 'False'
    grid: 'True'
    label1: LMMSE
    label2: SIC
    marker2: '0'
    nconnections: '2'
    size: '40'
    srate: '10'
    style2: '0'
    type: float
    update_time: '10'
    width1: '2'
    width2: '2'
    ylabel: BER
    ymin: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_file_source_0_0_1, '0', blocks_stream_to_tagged_stream_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_ofdm_demod_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', ncjt_ofdm_demod_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', ncjt_ofdm_demod_0_0_1, '0']
- [blocks_throttle2_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_ltf_chanest_0, '0', blocks_file_sink_0, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_sic_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', blocks_file_sink_0_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_ltf_chanest_0, '1', ncjt_sic_detect_0, '1']
- [ncjt_ltf_chanest_0, '2', blocks_file_sink_0_1, '0']
- [ncjt_ltf_chanest_0, '2', ncjt_mimo_detect_0, '2']
- [ncjt_ltf_chanest_0, '2', ncjt_sic_detect_0, '2']
- [ncjt_ltf_chanest_0, '3', blocks_file_sink_0_2, '0']
- [ncjt_ltf_chanest_0, '3', ncjt_mimo_detect_0, '3']
- [ncjt_ltf_chanest_0, '3', ncjt_sic_detect_0, '3']
- [ncjt_ltf_chanest_0_0, '0', blocks_file_sink_0_1_0, '0']
- [ncjt_ltf_chanest_0_0, '1', blocks_file_sink_0_1_0_0, '0']
- [ncjt_mimo_detect_0, '0', ncjt_qam_demapper_0_0, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0_1, '0']
- [ncjt_mimo_detect_0, '1', ncjt_qam_demapper_0_0, '1']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_0_0, '0', ncjt_ltf_chanest_0, '2']
- [ncjt_ofdm_demod_0_0_1, '0', ncjt_ltf_chanest_0, '3']
- [ncjt_pkt_err_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0, '1', qtgui_time_sink_x_0, '1']
- [ncjt_pkt_err_0_0, '0', blocks_null_sink_0, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_qam_demapper_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_qam_demapper_0, '1', ncjt_pkt_err_0, '1']
- [ncjt_qam_demapper_0_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_qam_demapper_0_0, '1', ncjt_pkt_err_0_0, '1']
- [ncjt_sic_detect_0, '0', ncjt_qam_demapper_0, '0']
- [ncjt_sic_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_sic_detect_0, '1', ncjt_qam_demapper_0, '1']
- [ncjt_sic_detect_0, '1', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-80-g0e28fd53
