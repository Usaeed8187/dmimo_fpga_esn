options:
  parameters:
    author: Nima
    generate_options: qt_gui
    id: software_sim
    output_language: python
    thread_safe_setters: '1'
    title: NCJT SC 1Tx Software
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '50'
  states: {}
- name: ctrl_enabled
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ctrl_polar_coding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: frames_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: init_code_rate
  id: variable
  parameters:
    value: '6'
  states: {}
- name: init_phase1_bits_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: init_phase2_bits_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: init_phase3_bits_per_sym
  id: variable
  parameters:
    value: '8'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_ofdm_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_streams
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_subcarriers
  id: variable
  parameters:
    value: '56'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: frames_per_sec
  states: {}
- name: rgmode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '2080'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1_1_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_1_1_0_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1_1_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1_1_0_0_1_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_1_1_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: 2coded
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_1
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    name: 1info
    type: byte
  states: {state: disabled}
- name: ncjt_demapper_0
  id: ncjt_demapper
  parameters:
    coded: 'True'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_demapper_0_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_demapper_0_0_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_demapper_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    rgmode: rgmode
  states: {}
- name: ncjt_err_stats_0_0
  id: ncjt_err_stats
  parameters:
    caption: Phase 3 Rx (RX UE 2)
    cols: '3'
    dark: 'True'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {state: disabled}
- name: ncjt_err_stats_0_0_0
  id: ncjt_err_stats
  parameters:
    caption: PDC HLL
    cols: '3'
    dark: 'True'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {}
- name: ncjt_err_stats_0_0_0_0
  id: ncjt_err_stats
  parameters:
    caption: PDC MAJORITY
    cols: '3'
    dark: 'True'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {state: disabled}
- name: ncjt_err_stats_0_0_1
  id: ncjt_err_stats
  parameters:
    caption: Phase 3 Rx (RX UE 1)
    cols: '3'
    dark: 'False'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {state: disabled}
- name: ncjt_err_stats_0_1
  id: ncjt_err_stats
  parameters:
    caption: Phase 1 Rx (TX UE)
    cols: '3'
    dark: 'False'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {}
- name: ncjt_err_stats_x
  id: ncjt_err_stats
  parameters:
    caption: Phase 2 Rx (RX UE)
    cols: '3'
    dark: 'False'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {state: disabled}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    code_rate: init_code_rate
    gui_hint: (0, 0, 1, 1)
    mcs: 'True'
    noair: 'True'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    reset: 'True'
  states: {}
- name: ncjt_mapper_muxer_0_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: init_code_rate
    debug: 'False'
    deterministic_input: deterministic
    nstrm: num_streams
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    rgmode: rgmode
  states: {}
- name: ncjt_noair_0
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: frames_per_sec
    num_drop_init_packets: '0'
    phase: '2'
    rgmode: rgmode
    snr_db: SNR
  states: {}
- name: ncjt_noair_0_0
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: frames_per_sec
    num_drop_init_packets: '0'
    phase: '1'
    rgmode: rgmode
    snr_db: SNR
  states: {}
- name: ncjt_noair_0_1
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: frames_per_sec
    num_drop_init_packets: '0'
    phase: '3'
    rgmode: rgmode
    snr_db: SNR
  states: {}
- name: ncjt_noair_0_1_0
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: frames_per_sec
    num_drop_init_packets: '0'
    phase: '3'
    rgmode: rgmode
    snr_db: SNR
  states: {}
- name: ncjt_pdc_0
  id: ncjt_pdc
  parameters:
    combiner: '1'
    debug: 'False'
    deterministic_input: deterministic
    expire_ms: '100'
    num_copies: '3'
    num_threads: '1'
    rgmode: rgmode
  states: {}
- name: ncjt_remapper_muxer_0_0_0
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: num_streams
    reencode: 'True'
    rgmode: rgmode
  states: {}
- name: ncjt_remapper_muxer_1
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: '1'
    reencode: 'False'
    rgmode: rgmode
  states: {}
- name: ncjt_remapper_muxer_1_0
  id: ncjt_remapper_muxer
  parameters:
    debug: 'False'
    nstrm: '1'
    reencode: 'False'
    rgmode: rgmode
  states: {}
- name: ncjt_rg_demapper_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: num_streams
    phase: '2'
    rgmode: rgmode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: num_streams
    phase: '3'
    rgmode: rgmode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_0_0
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: num_streams
    phase: '3'
    rgmode: rgmode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_demapper_0_1
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: num_streams
    phase: '1'
    rgmode: rgmode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: num_streams
    numue: '1'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'True'
    nstrm: num_streams
    numue: '2'
    rgmode: rgmode
    ueidx: '1'
  states: {}
- name: ncjt_rg_mapper_0_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'True'
    nstrm: num_streams
    numue: '2'
    rgmode: rgmode
    ueidx: '2'
  states: {}
- name: ncjt_rg_mapper_0_1
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: num_streams
    numue: '1'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_udp_video_pub_0
  id: ncjt_udp_video_pub
  parameters:
    grp: 239.0.0.1
    port: '9120'
  states: {}
- name: ncjt_udp_video_pub_0_0
  id: ncjt_udp_video_pub
  parameters:
    grp: 239.0.0.1
    port: '9112'
  states: {}
- name: ncjt_udp_video_pub_0_0_0
  id: ncjt_udp_video_pub
  parameters:
    grp: 239.0.0.1
    port: '9110'
  states: {state: disabled}

connections:
- [blocks_head_0, '0', ncjt_rg_mapper_0_1, '0']
- [ncjt_demapper_0, '0', blocks_null_sink_0_1_1_0_0, '0']
- [ncjt_demapper_0, '0', ncjt_err_stats_x, '0']
- [ncjt_demapper_0, '1', ncjt_remapper_muxer_1, '0']
- [ncjt_demapper_0, '1', ncjt_remapper_muxer_1_0, '0']
- [ncjt_demapper_0_0, '0', blocks_null_sink_0_1_1_0_0_1, '0']
- [ncjt_demapper_0_0, '0', ncjt_err_stats_0_0, '0']
- [ncjt_demapper_0_0_0, '0', blocks_null_sink_0_1_1_0_0_1_0, '0']
- [ncjt_demapper_0_0_0, '0', ncjt_err_stats_0_0_1, '0']
- [ncjt_demapper_1, '0', blocks_tag_debug_0, '0']
- [ncjt_demapper_1, '0', ncjt_remapper_muxer_0_0_0, '0']
- [ncjt_demapper_1, '0', ncjt_udp_video_pub_0, '0']
- [ncjt_knobs_0, reset, ncjt_err_stats_0_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_0_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_0_0_0, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_0_1, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_0_1, reset]
- [ncjt_knobs_0, reset, ncjt_err_stats_x, reset]
- [ncjt_knobs_0, s_code_rate, ncjt_mapper_muxer_0_0, s_code_rate]
- [ncjt_knobs_0, s_modtypes, ncjt_mapper_muxer_0_0, s_modtypes]
- [ncjt_knobs_0, s_snr1, ncjt_noair_0_0, s_snr]
- [ncjt_knobs_0, s_snr2, ncjt_noair_0, s_snr]
- [ncjt_knobs_0, s_snr3, ncjt_noair_0_1, s_snr]
- [ncjt_knobs_0, s_snr3, ncjt_noair_0_1_0, s_snr]
- [ncjt_mapper_muxer_0_0, '0', blocks_head_0, '0']
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_0_1, '0']
- [ncjt_noair_0, '0', ncjt_rg_demapper_0, '0']
- [ncjt_noair_0, '1', ncjt_rg_demapper_0, '1']
- [ncjt_noair_0_0, '0', blocks_null_sink_0_1, '0']
- [ncjt_noair_0_0, '0', ncjt_rg_demapper_0_1, '0']
- [ncjt_noair_0_0, '1', blocks_null_sink_0, '0']
- [ncjt_noair_0_0, '1', ncjt_rg_demapper_0_1, '1']
- [ncjt_noair_0_1, '0', ncjt_rg_demapper_0_0, '0']
- [ncjt_noair_0_1, '1', ncjt_rg_demapper_0_0, '1']
- [ncjt_noair_0_1_0, '0', ncjt_rg_demapper_0_0_0, '0']
- [ncjt_noair_0_1_0, '1', ncjt_rg_demapper_0_0_0, '1']
- [ncjt_pdc_0, '0', ncjt_udp_video_pub_0_0, '0']
- [ncjt_remapper_muxer_0_0_0, '0', blocks_null_sink_0_1_1, '0']
- [ncjt_remapper_muxer_0_0_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_remapper_muxer_1, '0', blocks_null_sink_0_1_1_0_1, '0']
- [ncjt_remapper_muxer_1, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_remapper_muxer_1_0, '0', ncjt_rg_mapper_0_0_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_demapper_0, '0']
- [ncjt_rg_demapper_0, '0', ncjt_pdc_0, '2']
- [ncjt_rg_demapper_0, '1', ncjt_demapper_0, '1']
- [ncjt_rg_demapper_0, '1', ncjt_pdc_0, '5']
- [ncjt_rg_demapper_0_0, '0', ncjt_demapper_0_0, '0']
- [ncjt_rg_demapper_0_0, '0', ncjt_pdc_0, '0']
- [ncjt_rg_demapper_0_0, '1', ncjt_demapper_0_0, '1']
- [ncjt_rg_demapper_0_0, '1', ncjt_pdc_0, '3']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_demapper_0_0_0, '0']
- [ncjt_rg_demapper_0_0_0, '0', ncjt_pdc_0, '1']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_demapper_0_0_0, '1']
- [ncjt_rg_demapper_0_0_0, '1', ncjt_pdc_0, '4']
- [ncjt_rg_demapper_0_1, '0', blocks_null_sink_0_1_0, '0']
- [ncjt_rg_demapper_0_1, '0', blocks_tag_debug_0_0, '0']
- [ncjt_rg_demapper_0_1, '0', ncjt_demapper_1, '0']
- [ncjt_rg_demapper_0_1, '1', blocks_null_sink_1_0, '0']
- [ncjt_rg_demapper_0_1, '1', ncjt_demapper_1, '1']
- [ncjt_rg_mapper_0, '0', blocks_null_sink_0_1_1_0, '0']
- [ncjt_rg_mapper_0, '0', ncjt_noair_0, '0']
- [ncjt_rg_mapper_0_0, '0', ncjt_noair_0_1, '0']
- [ncjt_rg_mapper_0_0_0, '0', ncjt_noair_0_1_0, '0']
- [ncjt_rg_mapper_0_1, '0', blocks_null_sink_0_0, '0']
- [ncjt_rg_mapper_0_1, '0', ncjt_noair_0_0, '0']
- [ncjt_udp_video_pub_0, '0', ncjt_err_stats_0_1, '0']
- [ncjt_udp_video_pub_0_0, '0', ncjt_err_stats_0_0_0, '0']
- [ncjt_udp_video_pub_0_0_0, '0', ncjt_err_stats_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
