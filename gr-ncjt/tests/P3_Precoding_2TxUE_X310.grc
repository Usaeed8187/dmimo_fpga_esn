options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3_precoding_2txue_x310
    output_language: python
    title: P3 UL Precoding Test (2 TxUE)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: sc_num*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntx
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '6'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sc_num
  id: variable
  parameters:
    value: '52'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/mu_mimo/2t2s/" + qam_type + "/strm_data_s1.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"../../data/mu_mimo/2t2s/" + qam_type + "/strm_data_s2.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '3'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '3'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0_0
  id: ncjt_ofdm_mod
  parameters:
    affinity: '4'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_1
  id: ncjt_ofdm_mod
  parameters:
    affinity: '4'
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '1'
    debug: 'False'
    framelen: frame_data_len
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2_t1.bin"'
    minoutbuf: '65536'
    modtype: qam_order
    mucpt: 'True'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    ueidx: '0'
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'True'
    affinity: '2'
    debug: 'False'
    framelen: frame_data_len
    ltfdata: '"../../data/mu_mimo/2t2s/" + qam_type + "/ltf2x2_t2.bin"'
    minoutbuf: '65536'
    modtype: qam_order
    mucpt: 'True'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
    numue: '2'
    ueidx: '1'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_noltfx.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms+2
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '5.0'
  states: {}
- name: ncjt_tx_frm_ctrl_0_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'True'
    debug: 'False'
    delay: '0'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/preamble_null.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms+2
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: '5.0'
  states: {}
- name: ncjt_ul_precoding_0
  id: ncjt_ul_precoding
  parameters:
    csifile: ''
    debug: 'False'
    eigenmode: 'False'
    loadcsi: 'False'
    ndatasyms: num_data_syms
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    wideband: 'True'
  states: {}
- name: ncjt_ul_precoding_0_0
  id: ncjt_ul_precoding
  parameters:
    csifile: ''
    debug: 'False'
    eigenmode: 'False'
    loadcsi: 'False'
    ndatasyms: num_data_syms
    nss: '1'
    ntx: '2'
    ntx_gnb: '4'
    numltfsyms: '2'
    wideband: 'True'
  states: {}
- name: uhd_usrp_sink_0_1
  id: uhd_usrp_sink
  parameters:
    affinity: '5'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source1: external
    dev_addr: '"addr0=192.168.30.2, addr1=192.168.40.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', ncjt_rg_mapper_0_0, '0']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_ofdm_mod_0_0_0, '0', ncjt_tx_frm_ctrl_0_0, '1']
- [ncjt_ofdm_mod_0_1, '0', ncjt_tx_frm_ctrl_0_0, '0']
- [ncjt_rg_mapper_0, '0', ncjt_ul_precoding_0, '0']
- [ncjt_rg_mapper_0_0, '0', ncjt_ul_precoding_0_0, '0']
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0_1, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0_1, '1']
- [ncjt_tx_frm_ctrl_0_0, '0', uhd_usrp_sink_0_1, '2']
- [ncjt_tx_frm_ctrl_0_0, '1', uhd_usrp_sink_0_1, '3']
- [ncjt_ul_precoding_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_ul_precoding_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_ul_precoding_0_0, '0', ncjt_ofdm_mod_0_1, '0']
- [ncjt_ul_precoding_0_0, '1', ncjt_ofdm_mod_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
