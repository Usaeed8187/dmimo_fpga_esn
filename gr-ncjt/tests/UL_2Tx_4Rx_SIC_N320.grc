options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: dl_4rx_n320
    output_language: python
    title: Downlink 2Tx 4Rx
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '1.0'
    step: '0.5'
    stop: '60'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest1.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest3.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/cpe_comp.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/csi_data.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err.bin
    type: int
    vlen: '2'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest4.bin
    type: complex
  states: {state: disabled}
- name: ncjt_mu_chanest_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '2'
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_mu_chanest_0_0
  id: ncjt_mu_chanest
  parameters:
    affinity: '3'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '2'
    nue: '2'
    removecs: 'False'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '2'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_1
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_2
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '1'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    maxcorrlen: '4000'
    minoutbuf: '32768'
    nchans: '4'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    affinity: '6'
    berout: 'True'
    debug: 'True'
    filename: '"../../data/mu_mimo/2t2s/" + qam_type + "/strm_data.bin"'
    logfreq: '50'
    nstrms: '2'
  states: {}
- name: ncjt_qam_demapper_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '6'
    debug: 'False'
    minoutbuf: '32768'
    modtype: qam_order
    nstrms: '2'
    usecsi: 'False'
  states: {}
- name: ncjt_sic_detect_0
  id: ncjt_sic_detect
  parameters:
    debug: 'False'
    fftsize: fft_size
    modtype: qam_order
    ndatasymbols: num_data_syms
    nrx: '4'
    nss: '2'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    ant2: '"TX/RX"'
    ant3: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.60.2,addr1=192.168.40.2"'
    gain0: rx_gain
    gain1: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source0: external
    lo_source1: external
    lo_source2: external
    lo_source3: external
    nchan: '4'
    num_mboards: '2'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    show_lo_controls: 'True'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_mu_chanest_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [ncjt_mu_chanest_0, '0', ncjt_sic_detect_0, '0']
- [ncjt_mu_chanest_0, '1', blocks_file_sink_0_0_1_0, '0']
- [ncjt_mu_chanest_0, '1', ncjt_sic_detect_0, '1']
- [ncjt_mu_chanest_0, cpe, blocks_file_sink_0_0_1_0_0, '0']
- [ncjt_mu_chanest_0, csi, blocks_file_sink_0_0_1_0_0_1, '0']
- [ncjt_mu_chanest_0_0, '0', ncjt_sic_detect_0, '2']
- [ncjt_mu_chanest_0_0, '1', ncjt_sic_detect_0, '3']
- [ncjt_ofdm_demod_0, '0', ncjt_mu_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_mu_chanest_0, '1']
- [ncjt_ofdm_demod_0_1, '0', ncjt_mu_chanest_0_0, '1']
- [ncjt_ofdm_demod_0_2, '0', ncjt_mu_chanest_0_0, '0']
- [ncjt_pkt_detect_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_pkt_detect_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_pkt_detect_0, '2', ncjt_ofdm_demod_0_2, '0']
- [ncjt_pkt_detect_0, '3', ncjt_ofdm_demod_0_1, '0']
- [ncjt_pkt_err_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_qam_demapper_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_qam_demapper_0, '1', ncjt_pkt_err_0, '1']
- [ncjt_sic_detect_0, '0', ncjt_qam_demapper_0, '0']
- [ncjt_sic_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_sic_detect_0, '1', ncjt_qam_demapper_0, '1']
- [ncjt_sic_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0_0_1_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']
- [uhd_usrp_source_0, '2', ncjt_pkt_detect_0, '2']
- [uhd_usrp_source_0, '3', ncjt_pkt_detect_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
