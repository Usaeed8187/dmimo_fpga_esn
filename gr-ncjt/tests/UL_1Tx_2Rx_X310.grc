options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: ul_1tx_2rx_x310
    output_language: python
    title: UL 1Tx 2Rx (MRC)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.55e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '3'
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest1.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/rxsig_chest2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err_mrc.bin
    type: int
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err_1.bin
    type: int
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err_2.bin
    type: int
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/1x1/256QAM/txsig_1x1_s1.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'True'
    debug: 'True'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: num_ltf_syms
    nrx: '2'
    ntx: '1'
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.6'
    affinity: '2'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    maxcorrlen: '4000'
    minoutbuf: '32768'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    samplerate: samp_rate
    syncall: 'False'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'True'
    filename: '"../data/1x1/256QAM/strm_data_1x1.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_pkt_err_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../data/1x1/256QAM/strm_data_1x1.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_pkt_err_0_0_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../data/1x1/256QAM/strm_data_1x1.bin"'
    logfreq: '50'
    nstrms: '1'
  states: {}
- name: ncjt_qam_demapper_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: '8'
    nstrms: '1'
    usecsi: 'True'
  states: {}
- name: ncjt_qam_demapper_0_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: '8'
    nstrms: '1'
    usecsi: 'False'
  states: {}
- name: ncjt_qam_demapper_0_0_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: '8'
    nstrms: '1'
    usecsi: 'False'
  states: {}
- name: ncjt_rx_mrc_0
  id: ncjt_rx_mrc
  parameters:
    debug: 'False'
    fftsize: '64'
    nrx: '2'
    nsymbols: '40'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    color2: blue
    color3: red
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: MRC
    label2: Rx 1
    label3: Rx2
    nconnections: '3'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    width2: '2'
    width3: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    center_freq0: rf_freq
    clock_rate: 200e6
    dev_addr: usrp_addr
    gain0: tx_gain
    len_tag_name: '"tx_pkt_len"'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: usrp_addr
    gain0: rx_gain
    gain1: rx_gain+5
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_ltf_chanest_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_rx_mrc_0, '0']
- [ncjt_ltf_chanest_0, '1', blocks_file_sink_0_0_1_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_rx_mrc_0, '1']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_pkt_detect_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_pkt_detect_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_pkt_err_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_pkt_err_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1_0, '0']
- [ncjt_pkt_err_0_0, '1', qtgui_time_sink_x_0, '1']
- [ncjt_pkt_err_0_0_0, '0', blocks_file_sink_0_0_1_0_0_0_1_0_0, '0']
- [ncjt_pkt_err_0_0_0, '1', qtgui_time_sink_x_0, '2']
- [ncjt_qam_demapper_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_qam_demapper_0_0, '0', ncjt_pkt_err_0_0, '0']
- [ncjt_qam_demapper_0_0_0, '0', ncjt_pkt_err_0_0_0, '0']
- [ncjt_rx_mrc_0, '0', ncjt_qam_demapper_0, '0']
- [ncjt_rx_mrc_0, '1', ncjt_qam_demapper_0, '1']
- [ncjt_rx_mrc_0, '2', ncjt_qam_demapper_0_0, '0']
- [ncjt_rx_mrc_0, '2', qtgui_const_sink_x_0, '0']
- [ncjt_rx_mrc_0, '3', ncjt_qam_demapper_0_0_0, '0']
- [ncjt_rx_mrc_0, '3', qtgui_const_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-80-g0e28fd53
