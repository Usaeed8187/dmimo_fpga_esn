options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: dl_2tx_n320
    output_language: python
    title: DL_2Tx_N320
  states: {}

blocks:
- name: pkts_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.45e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '1.0'
    stop: '60'
    value: '40'
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.40.2"'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/64QAM/txsig_2x2_s1.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/64QAM/txsig_2x2_s2.bin"'
    pktsize: '0'
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    dev_addr: usrp_addr
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-80-g0e28fd53
