options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_sc_ncjt_1rx
    output_language: python
    title: SC-NCJT Rx
  states: {}

blocks:
- name: lo_off
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: pkt_size
  id: variable
  parameters:
    value: 320*16
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '240'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '28'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s1.bin"'
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: '"/tmp/rx_iqdata_s2.bin"'
    type: complex
    unbuffered: 'True'
  states: {}
- name: ncjt_pkt_detect_0
  id: ncjt_pkt_detect
  parameters:
    acorrthrd: '0.65'
    affinity: '1'
    dataframelen: pkt_size
    debug: 'False'
    maxcorrlen: '4000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: preamble_len
    samplerate: samp_rate
    syncall: 'True'
    xcorrthrd: '0.5'
  states: {}
- name: ncjt_sync_all_0
  id: ncjt_sync_all
  parameters:
    debug: 'True'
    num_rx: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: '"addr=192.168.30.2"'
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [ncjt_pkt_detect_0, '0', blocks_file_sink_0_0_1, '0']
- [ncjt_pkt_detect_0, '1', blocks_file_sink_0_0_1_0, '0']
- [ncjt_pkt_detect_0, rxrdy, ncjt_sync_all_0, syncst]
- [ncjt_sync_all_0, allsync, ncjt_pkt_detect_0, allrdy]
- [uhd_usrp_source_0, '0', ncjt_pkt_detect_0, '0']
- [uhd_usrp_source_0, '1', ncjt_pkt_detect_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
