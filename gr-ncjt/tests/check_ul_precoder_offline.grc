options:
  parameters:
    author: usama
    generate_options: qt_gui
    id: check_ul_precoder_offline
    output_language: python
    title: Check UL Precoder (Offline)
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: csi_data_len
  id: variable
  parameters:
    value: 52*2*4
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*nss*num_data_syms*mod_order
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: modtype
  id: variable
  parameters:
    value: '"16QAM"'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '6'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.65e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/precoded_sig_tx_1.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/precoded_sig_tx_2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_0_1_1
  id: blocks_file_sink
  parameters:
    file: /tmp/sig_tx.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../data/1x1/" + modtype + "/strm_data_1x1.bin"'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '1'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ncjt_rg_mapper_0_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    debug: 'False'
    framelen: frame_data_len
    modtype: mod_order
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: '1'
  states: {}
- name: ncjt_ul_precoding_offline_1
  id: ncjt_ul_precoding_offline
  parameters:
    debug: 'True'
    dl_nrx: '2'
    dl_ntx: '4'
    eigenmode: 'True'
    filename: '"/tmp/csi_data.bin"'
    ndatasyms: num_data_syms
    nprecodedsyms: num_data_syms
    nss: nss
    numhtsyms: '0'
    ul_ntx: '2'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0_0, '0']
- [blocks_throttle2_0, '0', ncjt_ul_precoding_offline_1, '0']
- [ncjt_rg_mapper_0_0, '0', blocks_file_sink_0_0_1_0_0_0_0_1_1, '0']
- [ncjt_rg_mapper_0_0, '0', blocks_throttle2_0, '0']
- [ncjt_ul_precoding_offline_1, '0', blocks_file_sink_0_0_1_0_0_0_0_1, '0']
- [ncjt_ul_precoding_offline_1, '1', blocks_file_sink_0_0_1_0_0_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
