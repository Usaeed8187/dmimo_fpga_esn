options:
  parameters:
    author: Nima
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: software_sim_1str
    output_language: python
    title: NCJT SC 1Tx Software
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '60'
  states: {}
- name: ctrl_polar_coding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: deterministic
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: frames_per_sec
  id: variable
  parameters:
    value: '50'
  states: {}
- name: init_code_rate
  id: variable
  parameters:
    value: '0'
  states: {}
- name: init_phase1_bits_per_sym
  id: variable
  parameters:
    value: '6'
  states: {}
- name: init_phase2_bits_per_sym
  id: variable
  parameters:
    value: '6'
  states: {}
- name: init_phase3_bits_per_sym
  id: variable
  parameters:
    value: '6'
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: num_streams
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: frames_per_sec
  states: {}
- name: rgmode
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: ncjt_demapper_1
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    mcast_port: '3123'
    rgmode: rgmode
  states: {}
- name: ncjt_demapper_1_0
  id: ncjt_demapper
  parameters:
    coded: 'False'
    debug: 'False'
    deterministic_input: deterministic
    mcast_port: '3124'
    rgmode: rgmode
  states: {state: disabled}
- name: ncjt_err_stats_0_1
  id: ncjt_err_stats
  parameters:
    caption: Phase 1 Rx (TX UE)
    cols: '3'
    dark: 'True'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {}
- name: ncjt_err_stats_0_1_0
  id: ncjt_err_stats
  parameters:
    caption: Phase 1 Rx (TX UE)
    cols: '3'
    dark: 'True'
    debug: 'False'
    frame_per_sec: frames_per_sec
    logfreq: '5'
    row_height: '300'
    show_birate: 'True'
    show_coded_ber: 'True'
    show_num_copies: 'False'
    show_per: 'True'
    show_throughput: 'True'
    show_uncoded_ber: 'False'
    show_video: '1'
  states: {state: disabled}
- name: ncjt_knobs_0
  id: ncjt_knobs
  parameters:
    code_rate: init_code_rate
    gui_hint: (0, 0, 1, 1)
    mcs: 'True'
    noair: 'True'
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    reset: 'True'
  states: {}
- name: ncjt_mapper_muxer_0_0
  id: ncjt_mapper_muxer
  parameters:
    code_rate: init_code_rate
    debug: 'False'
    deterministic_input: deterministic
    nstrm: num_streams
    phase1_modtype: init_phase1_bits_per_sym
    phase2_modtype: init_phase2_bits_per_sym
    phase3_modtype: init_phase3_bits_per_sym
    rgmode: rgmode
  states: {}
- name: ncjt_noair_0_0
  id: ncjt_noair
  parameters:
    debug: 'False'
    frame_per_sec: frames_per_sec
    num_drop_init_packets: '0'
    phase: '1'
    rgmode: rgmode
    snr_db: SNR
  states: {}
- name: ncjt_rg_demapper_0_1
  id: ncjt_rg_demapper
  parameters:
    debug: 'False'
    nstrm: '1'
    phase: '1'
    rgmode: rgmode
    usecsi: 'True'
  states: {}
- name: ncjt_rg_mapper_0_1
  id: ncjt_rg_mapper
  parameters:
    addcs: 'False'
    addltf: 'False'
    debug: 'False'
    ltfdata: ''
    mucpt: 'False'
    nstrm: num_streams
    numue: '1'
    rgmode: rgmode
    ueidx: '-1'
  states: {}
- name: ncjt_udp_video_pub_0
  id: ncjt_udp_video_pub
  parameters:
    grp: 239.0.0.1
    port: '9123'
  states: {}

connections:
- [ncjt_demapper_1, '0', ncjt_udp_video_pub_0, '0']
- [ncjt_demapper_1_0, '0', ncjt_err_stats_0_1_0, '0']
- [ncjt_knobs_0, s_code_rate, ncjt_mapper_muxer_0_0, s_code_rate]
- [ncjt_knobs_0, s_modtypes, ncjt_mapper_muxer_0_0, s_modtypes]
- [ncjt_knobs_0, s_snr1, ncjt_noair_0_0, s_snr]
- [ncjt_mapper_muxer_0_0, '0', blocks_tag_debug_0, '0']
- [ncjt_mapper_muxer_0_0, '0', ncjt_rg_mapper_0_1, '0']
- [ncjt_noair_0_0, '0', blocks_null_sink_1, '0']
- [ncjt_noair_0_0, '0', ncjt_rg_demapper_0_1, '0']
- [ncjt_noair_0_0, '1', blocks_null_sink_1_0, '0']
- [ncjt_noair_0_0, '1', ncjt_rg_demapper_0_1, '1']
- [ncjt_rg_demapper_0_1, '0', blocks_null_sink_0, '0']
- [ncjt_rg_demapper_0_1, '0', ncjt_demapper_1, '0']
- [ncjt_rg_demapper_0_1, '0', ncjt_demapper_1_0, '0']
- [ncjt_rg_demapper_0_1, '1', blocks_null_sink_0, '1']
- [ncjt_rg_demapper_0_1, '1', ncjt_demapper_1, '1']
- [ncjt_rg_demapper_0_1, '1', ncjt_demapper_1_0, '1']
- [ncjt_rg_mapper_0_1, '0', ncjt_noair_0_0, '0']
- [ncjt_udp_video_pub_0, '0', ncjt_err_stats_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
