options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: p3_synctest_txue
    output_language: python
    title: P2P3 SyncTest TxUE
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_data_len
  id: variable
  parameters:
    value: 52*nss*num_data_syms*qam_order
  states: {}
- name: modulations
  id: variable
  parameters:
    value: '{2: "QPSK", 4: "16QAM", 6: "64QAM", 8: "256QAM"}'
  states: {}
- name: nss
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_data_syms
  id: variable
  parameters:
    value: '40'
  states: {}
- name: num_ltf_syms
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '20'
  states: {}
- name: qam_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: qam_type
  id: variable
  parameters:
    value: modulations[qam_order]
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.65e9
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '20'
  states: {}
- name: usrp_address
  id: variable
  parameters:
    value: '"addr=192.168.30.2"'
  states: {}
- name: blocks_file_sink_0_0_1_0_0_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/pkt_err_txue.bin
    type: int
    vlen: '2'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '"../../data/su_mimo/2t2s/" + qam_type + "/tx_strm_data.bin"'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '65536'
    packet_len: frame_data_len
    type: byte
  states: {}
- name: ncjt_ltf_chanest_0
  id: ncjt_ltf_chanest
  parameters:
    affinity: '4'
    csi_fb: 'False'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    npreamblesyms: nss
    nrx: nss
    ntx: nss
    removecs: 'False'
  states: {}
- name: ncjt_mimo_detect_0
  id: ncjt_mimo_detect
  parameters:
    affinity: '5'
    debug: 'False'
    fftsize: fft_size
    logfreq: '50'
    minoutbuf: '32768'
    ndatasymbols: num_data_syms
    nrx: nss
    nss: nss
  states: {}
- name: ncjt_ofdm_demod_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_demod_0_0
  id: ncjt_ofdm_demod
  parameters:
    affinity: '3'
    cplen: cp_len
    fftsize: fft_size
    minoutbuf: '32768'
    symoffset: '12'
  states: {}
- name: ncjt_ofdm_mod_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_ofdm_mod_0_0
  id: ncjt_ofdm_mod
  parameters:
    cplen: cp_len
    debug: 'False'
    fftsize: fft_size
    minoutbuf: '32768'
    ntx: nss
    scaling: '0.5'
  states: {}
- name: ncjt_pkt_err_0
  id: ncjt_pkt_err
  parameters:
    berout: 'True'
    debug: 'False'
    filename: '"../../data/rx_sync/2x2/" + qam_type + "/strm_data_2x2.bin"'
    logfreq: '50'
    nstrms: '2'
  states: {}
- name: ncjt_qam_demapper_0
  id: ncjt_qam_demapper
  parameters:
    affinity: '5'
    debug: 'False'
    minoutbuf: '32768'
    modtype: qam_order
    nstrms: '2'
    usecsi: 'False'
  states: {}
- name: ncjt_rg_mapper_0
  id: ncjt_rg_mapper
  parameters:
    addcs: 'True'
    addltf: 'False'
    ctrlmodtype: '2'
    datamodtype: qam_order
    debug: 'False'
    fftsize: '64'
    framelen: frame_data_len
    ltfdata: ''
    minoutbuf: '65536'
    mucpt: 'False'
    nctrlsyms: '0'
    ndatasyms: num_data_syms
    npilotsyms: '0'
    nstrms: nss
    numue: '1'
    ueidx: '-1'
  states: {}
- name: ncjt_rx_sync_0
  id: ncjt_rx_sync
  parameters:
    acorrthrd: '0.65'
    dataframelen: (fft_size+cp_len)*(num_ltf_syms+num_data_syms)
    debug: 'False'
    lltf2: 'True'
    maxcorrlen: '2000'
    nchans: '2'
    pktspersec: pkts_per_sec
    preamblelen: (fft_size+cp_len)*3
    rxpwrthrd: '1e-3'
    samplerate: samp_rate
    xcorrthrd: '0.45'
  states: {}
- name: ncjt_tx_frm_ctrl_0
  id: ncjt_tx_frm_ctrl
  parameters:
    autostart: 'False'
    debug: 'False'
    delay: '0'
    filename: '"../../data/su_mimo/2t2s/" + qam_type + "/preamble.bin"'
    fs: samp_rate
    minoutbuf: '32768'
    ndatasyms: num_data_syms
    ntx: '2'
    padding: '1000'
    pktspersec: pkts_per_sec
    starttime: (0.25/pkts_per_sec) + 5.0
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.25'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,1
    legend: 'False'
    size: '512'
    type: complex
    update_time: '0.25'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark green
    entags: 'False'
    grid: 'True'
    gui_hint: (1,0,1,2)
    label1: LMMSE
    legend: 'False'
    size: '40'
    srate: '4'
    type: float
    update_time: '10'
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    affinity: '1'
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    affinity: '1'
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: rf_freq
    center_freq1: rf_freq
    clock_rate: 200e6
    clock_source0: external
    dev_addr: usrp_address
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', ncjt_rg_mapper_0, '0']
- [ncjt_ltf_chanest_0, '0', ncjt_mimo_detect_0, '0']
- [ncjt_ltf_chanest_0, '1', ncjt_mimo_detect_0, '1']
- [ncjt_mimo_detect_0, '0', ncjt_qam_demapper_0, '0']
- [ncjt_mimo_detect_0, '0', qtgui_const_sink_x_0, '0']
- [ncjt_mimo_detect_0, '1', ncjt_qam_demapper_0, '1']
- [ncjt_mimo_detect_0, '1', qtgui_const_sink_x_0_0, '0']
- [ncjt_ofdm_demod_0, '0', ncjt_ltf_chanest_0, '0']
- [ncjt_ofdm_demod_0_0, '0', ncjt_ltf_chanest_0, '1']
- [ncjt_ofdm_mod_0, '0', ncjt_tx_frm_ctrl_0, '0']
- [ncjt_ofdm_mod_0_0, '0', ncjt_tx_frm_ctrl_0, '1']
- [ncjt_pkt_err_0, '0', blocks_file_sink_0_0_1_0_0_0_1, '0']
- [ncjt_pkt_err_0, '1', qtgui_time_sink_x_0, '0']
- [ncjt_qam_demapper_0, '0', ncjt_pkt_err_0, '0']
- [ncjt_qam_demapper_0, '1', ncjt_pkt_err_0, '1']
- [ncjt_rg_mapper_0, '0', ncjt_ofdm_mod_0, '0']
- [ncjt_rg_mapper_0, '1', ncjt_ofdm_mod_0_0, '0']
- [ncjt_rx_sync_0, '0', ncjt_ofdm_demod_0, '0']
- [ncjt_rx_sync_0, '1', ncjt_ofdm_demod_0_0, '0']
- [ncjt_rx_sync_0, rxrdy, ncjt_tx_frm_ctrl_0, txen]
- [ncjt_rx_sync_0, rxtime, ncjt_tx_frm_ctrl_0, rxtime]
- [ncjt_rx_sync_0, uhdcmd, uhd_usrp_source_0, command]
- [ncjt_tx_frm_ctrl_0, '0', uhd_usrp_sink_0, '0']
- [ncjt_tx_frm_ctrl_0, '1', uhd_usrp_sink_0, '1']
- [uhd_usrp_source_0, '0', ncjt_rx_sync_0, '0']
- [uhd_usrp_source_0, '1', ncjt_rx_sync_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
