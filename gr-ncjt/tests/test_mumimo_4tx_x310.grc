options:
  parameters:
    author: donald
    generate_options: qt_gui
    id: test_mumimo_4tx_x310
    output_language: python
    title: Test MU-MIMO Uplink (TX)
  states: {}

blocks:
- name: pkt_size
  id: variable
  parameters:
    value: '8400'
  states: {}
- name: pkts_per_sec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '25'
  states: {}
- name: ncjt_burst_tx_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/tx4s_s1.bin"'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_0
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/tx4s_s2.bin"'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_1
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/tx4s_s3.bin"'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: ncjt_burst_tx_0_2
  id: ncjt_burst_tx
  parameters:
    debug: 'False'
    filename: '"../data/tx4s_s4.bin"'
    pktsize: pkt_size
    pktspersec: pkts_per_sec
    samplerate: samp_rate
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    affinity: '14'
    ant0: TX/RX
    ant1: TX/RX
    ant2: TX/RX
    ant3: TX/RX
    center_freq0: rf_freq
    center_freq1: rf_freq
    center_freq2: rf_freq
    center_freq3: rf_freq
    clock_rate: 200e6
    clock_source0: internal
    clock_source1: internal
    dev_args: '"addr0=192.168.40.2,addr1=192.168.60.2"'
    gain0: tx_gain
    gain1: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    len_tag_name: '"tx_pkt_len"'
    nchan: '4'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [ncjt_burst_tx_0, '0', uhd_usrp_sink_0_0, '0']
- [ncjt_burst_tx_0_0, '0', uhd_usrp_sink_0_0, '1']
- [ncjt_burst_tx_0_1, '0', uhd_usrp_sink_0_0, '2']
- [ncjt_burst_tx_0_2, '0', uhd_usrp_sink_0_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
